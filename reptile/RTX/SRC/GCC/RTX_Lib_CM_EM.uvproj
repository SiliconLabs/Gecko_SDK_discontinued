# Keil uVision project RTX_Lib_CM_EM.uvproj, settings and files
target CM4F_LE_hard-abi (ARM-GNU)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: RTX_CM4_HFP (library)
  AfterMake: cmd.exe /C copy CM4F_HFP\libRTX_CM4_HFP.a ..\..\LIB\GCC\
  group Kernel
    ../: rt_CMSIS.c rt_Task.c rt_System.c rt_Event.c rt_List.c rt_Mailbox.c rt_Semaphore.c rt_Time.c rt_Timer.c rt_Mutex.c rt_Robin.c rt_MemBox.c rt_Memory.c
  group HAL
    ./: SVC_Table.s HAL_CM0.s HAL_CM3.s HAL_CM4.s
    ../: HAL_CM.c
target CM4F_LE_softfp-abi (ARM-GNU)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: RTX_CM4_SFP (library)
  AfterMake: cmd.exe /C copy CM4F_SFP\libRTX_CM4_SFP.a ..\..\LIB\GCC\
