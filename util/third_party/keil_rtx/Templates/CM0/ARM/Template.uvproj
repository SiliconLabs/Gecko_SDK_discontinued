# Keil uVision project Template.uvproj, settings and files
target Simulator (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: Template
  c flags: Optim=1
  c include: ..\;..\..\..\INC
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x8000
  memory RVCT6: RAM 0x20000000 size 0x4000
  group Startup
    ./: startup_ARMCM0.s
    ../: system_ARMCM0.c
  group RTX Configuration
    ../../: RTX_Conf_CM.c
  group RTX Library
    ../../../LIB/ARM/: RTX_CM0.lib
  group Source Files
    ../../: main.c
