# Keil uVision project Template.uvproj, settings and files
target Simulator (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: Template
  c flags: Optim=1
  c include: ..\;..\..\..\INC
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x8000
  memory RVCT6: RAM 0x20000000 size 0x4000
  group Startup
    ./: startup_ARMCM4.s
    ../: system_ARMCM4.c
  group RTX Configuration
    ../../: RTX_Conf_CM.c
  group RTX Library
    ../../../LIB/ARM/: RTX_CM4.lib
  group Source Files
    ../../: main.c
