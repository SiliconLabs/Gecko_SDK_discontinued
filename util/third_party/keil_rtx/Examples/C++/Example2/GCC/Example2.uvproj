# Keil uVision project Example2.uvproj, settings and files
target Simulator (ARM-GNU)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: Example2
  group Startup
    ./: startup_ARMCM3.S
    ../: system_ARMCM3.c
  group RTX Configuration
    ../: RTX_Conf_CM.c
  group RTX Library
    ../../../../LIB/GCC/: libRTX_CM3.a
  group Source Files
    ./: Retarget.c
    ../: Serial.c CppSamp.cpp
  group Documentation
    ../: Abstract.txt
