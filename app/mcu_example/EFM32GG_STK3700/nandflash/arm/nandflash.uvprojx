# Keil uVision project nandflash.uvprojx, settings and files
target nandflash (ARM-ADS)
  device: EFM32GG990F1024 Silicon Labs
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0xFFFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: nandflash
  AfterMake: fromelf.exe --bin --output obj\nandflash.bin obj\nandflash.axf
  c flags: Optim=4 oTime=1
  c define: EFM32GG990F1024 DEBUG_EFM
  c misc: --c99
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\EFM32GG_STK3700\config
  asm define: EFM32GG990F1024 DEBUG_EFM
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_bcc.c bsp_stk.c bsp_trace.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: dmactrl.c nandflash.c retargetio.c retargetserial.c
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32GG/Source/ARM/: startup_efm32gg.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG/Source/: system_efm32gg.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_system.c em_usart.c
  group Source
    ../: main.c
