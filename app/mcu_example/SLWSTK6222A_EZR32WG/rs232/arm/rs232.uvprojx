# Keil uVision project rs232.uvprojx, settings and files
target rs232 (ARM-ADS)
  device: EZR32WG330F256R63 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(48000000) CPUTYPE("Cortex-M4") FPU2
  output: rs232
  AfterMake: fromelf.exe --bin --output obj\rs232.bin obj\rs232.axf
  c flags: Optim=1
  c define: EZR32WG330F256R63 DEBUG_EFM
  c misc: --c99
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EZR32WG\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\SLWSTK6222A_EZR32WG\config
  asm define: EZR32WG330F256R63 DEBUG_EFM
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Drivers
    ../../../../../hardware/kit/common/drivers/: retargetio.c retargetserial.c
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EZR32WG/Source/ARM/: startup_ezr32wg.s
    ../../../../../platform/Device/SiliconLabs/EZR32WG/Source/: system_ezr32wg.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_system.c em_cmu.c em_core.c em_emu.c em_gpio.c em_ebi.c em_usart.c em_leuart.c
  group Source
    ../: main.c
