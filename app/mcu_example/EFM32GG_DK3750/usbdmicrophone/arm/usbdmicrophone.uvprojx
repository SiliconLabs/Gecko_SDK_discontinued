# Keil uVision project usbdmicrophone.uvprojx, settings and files
target usbdmicrophone (ARM-ADS)
  device: EFM32GG990F1024 Silicon Labs
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0xFFFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: usbdmicrophone
  AfterMake: fromelf.exe --bin --output obj\usbdmicrophone.bin obj\usbdmicrophone.axf
  c flags: Optim=1
  c define: EFM32GG990F1024 DEBUG_EFM_USER
  c misc: --c99
  c include: ..\;..;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\platform\middleware\usb_gecko\inc;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\EFM32GG_DK3750\config;..\..\..\..\..\platform\emdrv\common\inc;..\..\..\..\..\platform\emdrv\dmadrv\inc
  asm define: EFM32GG990F1024 DEBUG_EFM_USER
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32GG/Source/ARM/: startup_efm32gg.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG/Source/: system_efm32gg.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_dk_3201.c bsp_trace.c
  group emdrv
    ../../../../../platform/emdrv/dmadrv/src/: dmadrv.c
  group drivers
    ../../../../../hardware/kit/common/drivers/: retargetio.c retargetserial.c dmactrl.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_adc.c em_cmu.c em_core.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_prs.c em_system.c em_timer.c em_usart.c
  group emusb
    ../../../../../platform/middleware/usb_gecko/src/: em_usbd.c em_usbdch9.c em_usbhal.c em_usbdep.c em_usbdint.c em_usbtimer.c
  group Source
    ../: main.c descriptors.c
