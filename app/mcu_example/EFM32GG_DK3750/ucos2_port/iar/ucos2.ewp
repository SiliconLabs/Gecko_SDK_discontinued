# IAR project ucos2.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32GG990F1024 SiliconLaboratories EFM32GG990F1024
  ICCARM.CCDefines: EFM32GG990F1024
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG\Include; ..\..\..\..\..\platform\emlib\inc; ..\src\bsp; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\EFM32GG_DK3750\config; ..\src\app; ..\..\..\..\..\platform\middleware\glib; ..\..\..\..\..\util\third_party\micrium\uCOS-II\uC-CPU; ..\..\..\..\..\util\third_party\micrium\uCOS-II\uC-LIB; ..\..\..\..\..\util\third_party\micrium\uCOS-II\uCOS-II\Source; ..\..\..\..\..\util\third_party\micrium\uCOS-II\uC-CPU\ARM-Cortex-M3\IAR; ..\..\..\..\..\util\third_party\micrium\uCOS-II\uCOS-II\Ports\ARM-Cortex-M3\Generic\IAR
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: EFM32GG990F1024
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ucos2.bin
  ILINK.IlinkOutputFile: ucos2.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32GG990F1024
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group APP
    ../src/app/: app.c app_hooks.c app_task_one.c app_task_two.c app_task_three.c
  group BSP
    ../src/bsp/: bsp-uart.c
    ../../../../../hardware/kit/common/bsp/: bsp_dk_3201.c bsp_dk_leds.c bsp_trace.c
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32GG/Source/IAR/: startup_efm32gg.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG/Source/: system_efm32gg.c
    ../../../../../util/third_party/micrium/Ports/CMSIS/IAR/: cmsis_wrapper.s
  group Drivers
    ../../../../../hardware/kit/common/drivers/: retargettft.c retargetio.c
  group Graphics
    ../../../../../platform/middleware/glib/dmd/ssd2119/: dmd_ssd2119_16bit.c dmdif_ssd2119_ebi16.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_emu.c em_ebi.c em_gpio.c em_system.c em_usart.c
  group uC/CPU
    ../../../../../util/third_party/micrium/uCOS-II/uC-CPU/: cpu_core.c
    ../../../../../util/third_party/micrium/uCOS-II/uC-CPU/ARM-Cortex-M3/IAR/: cpu_c.c cpu_a.asm
  group uC/LIB
    ../../../../../util/third_party/micrium/uCOS-II/uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group uC/OS-II
    ../../../../../util/third_party/micrium/uCOS-II/uCOS-II/Source/: ucos_ii.c
    ../../../../../util/third_party/micrium/uCOS-II/uCOS-II/Ports/ARM-Cortex-M3/Generic/IAR/: os_dbg.c os_cpu_c.c os_cpu_a.asm
