# Keil uVision project ucos3.uvprojx, settings and files
target ucos3 (ARM-ADS)
  device: EFM32GG990F1024 Silicon Labs
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0xFFFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: ucos3
  AfterMake: fromelf.exe --bin --output obj\ucos3.bin obj\ucos3.axf
  c flags: Optim=1 oTime=1
  c define: EFM32GG990F1024
  c misc: --c99
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\EFM32GG_DK3750\config;..\src\bsp;..\src\app;..\..\..\..\..\platform\middleware\glib;..\..\..\..\..\util\third_party\micrium\uCOS-III\uC-CPU;..\..\..\..\..\util\third_party\micrium\uCOS-III\uC-LIB;..\..\..\..\..\util\third_party\micrium\uCOS-III\uCOS-III\Source;..\..\..\..\..\util\third_party\micrium\uCOS-III\uC-CPU\ARM-Cortex-M3\RealView;..\..\..\..\..\util\third_party\micrium\uCOS-III\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView
  asm define: EFM32GG990F1024
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group APP
    ../src/app/: app.c app_hooks.c app_task_one.c app_task_two.c app_task_three.c
  group BSP
    ../src/bsp/: bsp-uart.c
    ../../../../../hardware/kit/common/bsp/: bsp_dk_3201.c bsp_dk_leds.c bsp_trace.c
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32GG/Source/ARM/: startup_efm32gg.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG/Source/: system_efm32gg.c
    ../../../../../util/third_party/micrium/Ports/CMSIS/ARM/: cmsis_wrapper.s
  group Drivers
    ../../../../../hardware/kit/common/drivers/: retargetio.c retargettft.c
  group Graphics
    ../../../../../platform/middleware/glib/dmd/ssd2119/: dmd_ssd2119_16bit.c dmdif_ssd2119_ebi16.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_emu.c em_ebi.c em_gpio.c em_system.c em_usart.c em_leuart.c
  group uC/CPU
    ../../../../../util/third_party/micrium/uCOS-III/uC-CPU/: cpu_core.c
    ../../../../../util/third_party/micrium/uCOS-III/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
  group uC/OS-III
    ../../../../../util/third_party/micrium/uCOS-III/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_mon.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../../../../../util/third_party/micrium/uCOS-III/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_c.c os_cpu_a.s
