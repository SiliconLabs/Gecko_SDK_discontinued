# Keil uVision project freertos_blink.uvprojx, settings and files
target freertos_blink (ARM-ADS)
  device: EFM32GG990F1024 Silicon Labs
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0xFFFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: freertos_blink
  AfterMake: fromelf.exe --bin --output obj\freertos_blink.bin obj\freertos_blink.axf
  c flags: Optim=4 oTime=1
  c define: EFM32GG990F1024 RVDS_ARMCM3_LM3S102 DEBUG_EFM
  c misc: --c99
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\platform\emdrv\sleep\inc;..\..\..\..\..\hardware\kit\common\bsp;..;..\..\..\..\..\util\third_party\freertos\Source\include;..\..\..\..\..\util\third_party\freertos\Source\portable\RVDS\ARM_CM3;..\..\..\..\..\hardware\kit\EFM32GG_DK3750\config
  asm define: EFM32GG990F1024 RVDS_ARMCM3_LM3S102 DEBUG_EFM
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32GG/Source/ARM/: startup_efm32gg.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG/Source/: system_efm32gg.c
  group BSP
    ../../../../../hardware/kit/common/bsp/: bsp_dk_3201.c bsp_dk_leds.c bsp_trace.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_burtc.c em_cmu.c em_core.c em_emu.c em_gpio.c em_rmu.c em_rtc.c em_ebi.c em_usart.c em_system.c
  group emdrv
    ../../../../../platform/emdrv/sleep/src/: sleep.c
  group freertos
    ../../../../../util/third_party/freertos/Source/: timers.c tasks.c queue.c list.c croutine.c event_groups.c
    ../../../../../util/third_party/freertos/Source/portable/MemMang/: heap_1.c
    ../../../../../util/third_party/freertos/Source/portable/RVDS/ARM_CM3/: port.c
  group Source
    ../: main.c low_power_tick_management.c
