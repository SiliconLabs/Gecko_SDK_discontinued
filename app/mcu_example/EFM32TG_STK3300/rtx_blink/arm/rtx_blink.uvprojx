# Keil uVision project rtx_blink.uvprojx, settings and files
target rtx_blink (ARM-ADS)
  device: EFM32TG840F32 Silicon Labs
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(14000000) CPUTYPE("Cortex-M3")
  output: rtx_blink
  AfterMake: fromelf.exe --bin --output obj\rtx_blink.bin obj\rtx_blink.axf
  c flags: Optim=4 oTime=1
  c define: EFM32TG840F32
  c misc: --c99
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32TG\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\util\third_party\keil_rtx\Inc;..\..\..\..\..\hardware\kit\EFM32TG_STK3300\config
  asm define: EFM32TG840F32
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32TG/Source/ARM/: startup_efm32tg.s
    ../../../../../platform/Device/SiliconLabs/EFM32TG/Source/: system_efm32tg.c
  group BSP
    ../../../../../hardware/kit/common/bsp/: bsp_trace.c bsp_stk_leds.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: segmentlcd.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_lcd.c em_system.c
  group Source
    ../: rtx_blink.c RTX_Conf_CM.c
  group Libraries
    ../../../../../util/third_party/keil_rtx/LIB/ARM/: RTX_CM3.lib
