# Keil uVision project blink.uvprojx, settings and files
target blink (ARM-ADS)
  device: EFM32TG840F32 Silicon Labs
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(14000000) CPUTYPE("Cortex-M3")
  output: blink
  AfterMake: fromelf.exe --bin --output obj\blink.bin obj\blink.axf
  c flags: Optim=1
  c define: EFM32TG840F32 DEBUG_EFM
  c misc: --c99
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32TG\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\EFM32TG_STK3300\config
  asm define: EFM32TG840F32 DEBUG_EFM
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32TG/Source/ARM/: startup_efm32tg.s
    ../../../../../platform/Device/SiliconLabs/EFM32TG/Source/: system_efm32tg.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_system.c em_usart.c
  group BSP
    ../../../../../hardware/kit/common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
  group Source
    ../: blink.c
