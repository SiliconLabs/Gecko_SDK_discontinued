# Keil uVision project weatherstation.uvprojx, settings and files
target weatherstation (ARM-ADS)
  device: EFM32TG840F32 Silicon Labs
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(14000000) CPUTYPE("Cortex-M3")
  output: weatherstation
  AfterMake: fromelf.exe --bin --output obj\weatherstation.bin obj\weatherstation.axf
  c flags: Optim=4
  c define: EFM32TG840F32
  c misc: --c99
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32TG\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\platform\emdrv\common\inc;..\..\..\..\..\platform\emdrv\rtcdrv\inc;..\..\..\..\..\platform\emdrv\rtcdrv\config;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\EFM32TG_STK3300\config;..\..\..\..\..\platform\middleware\glib;..
  asm define: EFM32TG840F32
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32TG/Source/ARM/: startup_efm32tg.s
    ../../../../../platform/Device/SiliconLabs/EFM32TG/Source/: system_efm32tg.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_trace.c
  group emdrv
    ../../../../../platform/emdrv/rtcdrv/src/: rtcdriver.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: segmentlcd.c si7013.c si114x_algorithm.c si114x_functions.c si1147_i2c.c i2cspm.c vddcheck.c
  group emlib
    ../../../../../platform/emlib/src/: em_adc.c em_assert.c em_cmu.c em_core.c em_emu.c em_gpio.c em_lcd.c em_rtc.c em_system.c em_i2c.c em_vcmp.c
  group Source
    ../: weatherstation.c graphics.c
