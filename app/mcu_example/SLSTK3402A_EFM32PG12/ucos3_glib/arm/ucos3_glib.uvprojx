# Keil uVision project ucos3_glib.uvprojx, settings and files
target ucos3_glib (ARM-ADS)
  device: EFM32PG12B500F1024GL125 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(38400000) CPUTYPE("Cortex-M4") FPU2
  output: ucos3_glib
  AfterMake: fromelf.exe --bin --output obj\ucos3_glib.bin obj\ucos3_glib.axf
  c flags: Optim=1 oTime=1 uC99=1 wLevel=2
  c define: EFM32PG12B500F1024GL125 DEBUG_EFM
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32PG12B\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\platform\emdrv\gpiointerrupt\inc;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\platform\middleware\glib;..\..\..\..\..\platform\middleware\glib\glib;..\..\..\..\..\platform\middleware\glib\dmd;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\SLSTK3402A_EFM32PG12\config;..\..\..\..\..\util\third_party\micrium\uCOS-III\uC-CPU;..\..\..\..\..\util\third_party\micrium\uCOS-III\uC-LIB;..\..\..\..\..\util\third_party\micrium\uCOS-III\uCOS-III\Source;..\..\..\..\..\util\third_party\micrium\uCOS-III\uC-CPU\ARM-Cortex-M4\RealView;..\..\..\..\..\util\third_party\micrium\uCOS-III\uCOS-III\Ports\ARM-Cortex-M\ARMv7-M\ARM;..;..\bsp
  asm define: EFM32PG12B500F1024GL125 DEBUG_EFM
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group bsp
    ../bsp/: bsp_os.c cpu_bsp.c
    ../../../../../hardware/kit/common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32PG12B/Source/ARM/: startup_efm32pg12b.s
    ../../../../../platform/Device/SiliconLabs/EFM32PG12B/Source/: system_efm32pg12b.c
    ../../../../../util/third_party/micrium/Ports/CMSIS/ARM/: cmsis_wrapper.s
  group Drivers
    ../../../../../hardware/kit/common/drivers/: display.c displayls013b7dh03.c displaypalemlib.c udelay.c
  group glib
    ../../../../../platform/middleware/glib/dmd/display/: dmd_display.c
    ../../../../../platform/middleware/glib/glib/: glib.c glib_bitmap.c glib_circle.c glib_line.c glib_polygon.c glib_rectangle.c glib_string.c glib_font_normal_8x8.c glib_font_narrow_6x8.c glib_font_number_16x20.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_emu.c em_gpio.c em_prs.c em_rtcc.c em_system.c em_usart.c
  group emdrv
    ../../../../../platform/emdrv/gpiointerrupt/src/: gpiointerrupt.c
  group uC-CPU
    ../../../../../util/third_party/micrium/uCOS-III/uC-CPU/: cpu_core.c
    ../../../../../util/third_party/micrium/uCOS-III/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
  group uC-LIB
    ../../../../../util/third_party/micrium/uCOS-III/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uCOS-III
    ../../../../../util/third_party/micrium/uCOS-III/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_mon.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_trace.h os_type.h os_var.c
    ../../../../../util/third_party/micrium/uCOS-III/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/ARM/: os_cpu_c.c os_cpu_a.asm
  group Source
    ../: main.c task.c hooks.c
