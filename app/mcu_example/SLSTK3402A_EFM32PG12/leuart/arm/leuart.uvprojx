# Keil uVision project leuart.uvprojx, settings and files
target leuart (ARM-ADS)
  device: EFM32PG12B500F1024GL125 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(38400000) CPUTYPE("Cortex-M4") FPU2
  output: leuart
  AfterMake: fromelf.exe --bin --output obj\leuart.bin obj\leuart.axf
  c flags: Optim=1 oTime=1 uC99=1 wLevel=2
  c define: EFM32PG12B500F1024GL125 DEBUG_EFM RETARGET_LEUART0
  c misc: --diag_suppress=C1296
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32PG12B\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\SLSTK3402A_EFM32PG12\config
  asm define: EFM32PG12B500F1024GL125 DEBUG_EFM RETARGET_LEUART0
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32PG12B/Source/ARM/: startup_efm32pg12b.s
    ../../../../../platform/Device/SiliconLabs/EFM32PG12B/Source/: system_efm32pg12b.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_system.c em_cmu.c em_core.c em_emu.c em_gpio.c em_leuart.c em_ldma.c
  group Source
    ../: main.c
