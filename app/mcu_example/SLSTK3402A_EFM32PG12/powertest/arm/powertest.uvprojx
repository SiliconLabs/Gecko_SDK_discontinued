# Keil uVision project powertest.uvprojx, settings and files
target powertest (ARM-ADS)
  device: EFM32PG12B500F1024GL125 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(38400000) CPUTYPE("Cortex-M4") FPU2
  output: powertest
  AfterMake: fromelf.exe --bin --output obj\powertest.bin obj\powertest.axf
  c flags: Optim=4 oTime=1 uC99=1 wLevel=2
  c define: EFM32PG12B500F1024GL125 DEBUG_EFM
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32PG12B\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\SLSTK3402A_EFM32PG12\config;..\..\..\..\..\platform\emdrv\common\inc;..\..\..\..\..\platform\emdrv\rtcdrv\inc;..
  asm define: EFM32PG12B500F1024GL125 DEBUG_EFM
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32PG12B/Source/ARM/: startup_efm32pg12b.s
    ../../../../../platform/Device/SiliconLabs/EFM32PG12B/Source/: system_efm32pg12b.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_emu.c em_system.c em_rtcc.c em_wdog.c
  group emdrv
    ../../../../../platform/emdrv/rtcdrv/src/: rtcdriver.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_trace.c
  group Source
    ../: main.c
