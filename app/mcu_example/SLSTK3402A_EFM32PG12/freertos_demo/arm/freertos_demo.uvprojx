# Keil uVision project freertos_demo.uvprojx, settings and files
target freertos_demo (ARM-ADS)
  device: EFM32PG12B500F1024GL125 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(38400000) CPUTYPE("Cortex-M4") FPU2
  output: freertos_demo
  AfterMake: fromelf.exe --bin --output obj\freertos_demo.bin obj\freertos_demo.axf
  c flags: Optim=1 oTime=1 uC99=1 wLevel=2
  c define: EFM32PG12B500F1024GL125 DEBUG_EFM
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32PG12B\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\platform\emdrv\sleep\inc;..\..\..\..\..\hardware\kit\common\bsp;..;..\..\..\..\..\util\third_party\freertos\Source\include;..\..\..\..\..\util\third_party\freertos\Demo\Common\include;..\..\..\..\..\util\third_party\freertos\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\hardware\kit\SLSTK3402A_EFM32PG12\config
  asm define: EFM32PG12B500F1024GL125 DEBUG_EFM
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32PG12B/Source/ARM/: startup_efm32pg12b.s
    ../../../../../platform/Device/SiliconLabs/EFM32PG12B/Source/: system_efm32pg12b.c
  group BSP
    ../../../../../hardware/kit/common/bsp/: bsp_trace.c bsp_stk_leds.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_emu.c em_gpio.c em_rmu.c em_rtcc.c em_system.c
  group emdrv
    ../../../../../platform/emdrv/sleep/src/: sleep.c
  group FreeRTOS
    ../../../../../util/third_party/freertos/Source/: timers.c tasks.c queue.c list.c croutine.c event_groups.c
    ../../../../../util/third_party/freertos/Source/portable/MemMang/: heap_4.c
    ../../../../../util/third_party/freertos/Source/portable/RVDS/ARM_CM4F/: port.c
  group Demo
    ../../../../../util/third_party/freertos/Demo/Common/Minimal/: TimerDemo.c EventGroupsDemo.c TaskNotify.c blocktim.c GenQTest.c recmutex.c semtest.c flop.c dynamic.c StaticAllocation.c
    ../../../../../util/third_party/freertos/Demo/Common/SiliconLaboratories/: low_power_tick_management_RTCC.c
  group Source
    ../: main.c
    ../Full_Demo/: main_full.c RegTest_Keil.c
    ../Low_Power_Demo/: main_low_power.c
