# Keil uVision project humitemp.uvprojx, settings and files
target humitemp (ARM-ADS)
  device: EFM32PG12B500F1024GL125 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(38400000) CPUTYPE("Cortex-M4") FPU2
  output: humitemp
  AfterMake: fromelf.exe --bin --output obj\humitemp.bin obj\humitemp.axf
  c flags: Optim=4 uC99=1 wLevel=2
  c define: EFM32PG12B500F1024GL125
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32PG12B\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\platform\emdrv\common\inc;..\..\..\..\..\platform\emdrv\rtcdrv\inc;..\..\..\..\..\platform\emdrv\rtcdrv\config;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\SLSTK3402A_EFM32PG12\config;..\..\..\..\..\platform\middleware\glib;..\..\..\..\..\platform\middleware\glib\glib;..\..\..\..\..\platform\middleware\glib\dmd;..
  asm define: EFM32PG12B500F1024GL125
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32PG12B/Source/ARM/: startup_efm32pg12b.s
    ../../../../../platform/Device/SiliconLabs/EFM32PG12B/Source/: system_efm32pg12b.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_bcc.c bsp_stk.c
  group emdrv
    ../../../../../platform/emdrv/rtcdrv/src/: rtcdriver.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: display.c displayls013b7dh03.c displaypalemlib.c udelay.c si7013.c i2cspm.c
  group glib
    ../../../../../platform/middleware/glib/dmd/display/: dmd_display.c
    ../../../../../platform/middleware/glib/glib/: glib.c glib_bitmap.c glib_circle.c glib_line.c glib_rectangle.c glib_string.c glib_font_normal_8x8.c glib_font_narrow_6x8.c
  group emlib
    ../../../../../platform/emlib/src/: em_adc.c em_assert.c em_system.c em_cmu.c em_core.c em_emu.c em_gpio.c em_leuart.c em_rtcc.c em_usart.c em_i2c.c
  group Source
    ../: humitemp.c graphics.c
