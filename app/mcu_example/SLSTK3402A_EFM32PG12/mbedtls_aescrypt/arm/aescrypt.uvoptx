<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectOpt xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_opt.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <Extensions>
    <cExt>*.c</cExt>
    <aExt>*.s*; *.src; *.a*</aExt>
    <oExt>*.obj</oExt>
    <lExt>*.lib</lExt>
    <tExt>*.txt; *.h; *.inc</tExt>
    <pExt>*.plm</pExt>
    <CppX>*.cpp</CppX>
  </Extensions>

  <DaveTm>
    <dwLowDateTime>0</dwLowDateTime>
    <dwHighDateTime>0</dwHighDateTime>
  </DaveTm>

  <Target>
    <TargetName>aescrypt</TargetName>
    <ToolsetNumber>0x4</ToolsetNumber>
    <ToolsetName>ARM-ADS</ToolsetName>
    <TargetOption>
      <CLKADS>38400000</CLKADS>
      <OPTTT>
        <gFlags>1</gFlags>
        <BeepAtEnd>1</BeepAtEnd>
        <RunSim>1</RunSim>
        <RunTarget>0</RunTarget>
      </OPTTT>
      <OPTHX>
        <HexSelection>1</HexSelection>
        <FlashByte>65535</FlashByte>
        <HexRangeLowAddress>0</HexRangeLowAddress>
        <HexRangeHighAddress>0</HexRangeHighAddress>
        <HexOffset>0</HexOffset>
      </OPTHX>
      <OPTLEX>
        <PageWidth>79</PageWidth>
        <PageLength>66</PageLength>
        <TabStop>8</TabStop>
        <ListingPath>.\lst\</ListingPath>
      </OPTLEX>
      <ListingPage>
        <CreateCListing>1</CreateCListing>
        <CreateAListing>1</CreateAListing>
        <CreateLListing>1</CreateLListing>
        <CreateIListing>0</CreateIListing>
        <AsmCond>1</AsmCond>
        <AsmSymb>1</AsmSymb>
        <AsmXref>0</AsmXref>
        <CCond>1</CCond>
        <CCode>0</CCode>
        <CListInc>0</CListInc>
        <CSymb>0</CSymb>
        <LinkerCodeListing>0</LinkerCodeListing>
      </ListingPage>
      <OPTXL>
        <LMap>1</LMap>
        <LComments>1</LComments>
        <LGenerateSymbols>1</LGenerateSymbols>
        <LLibSym>1</LLibSym>
        <LLines>1</LLines>
        <LLocSym>1</LLocSym>
        <LPubSym>1</LPubSym>
        <LXref>0</LXref>
        <LExpSel>0</LExpSel>
      </OPTXL>
      <OPTFL>
        <tvExp>1</tvExp>
        <tvExpOptDlg>0</tvExpOptDlg>
        <IsCurrentTarget>1</IsCurrentTarget>
      </OPTFL>
      <CpuCode>255</CpuCode>
      <DllOpt>
        <SimDllName>SARMCM3.DLL</SimDllName>
        <SimDllArguments></SimDllArguments>
        <SimDlgDllName>DCM.DLL</SimDlgDllName>
        <SimDlgDllArguments>-pCM4</SimDlgDllArguments>
        <TargetDllName>SARMCM3.DLL</TargetDllName>
        <TargetDllArguments></TargetDllArguments>
        <TargetDlgDllName>TCM.DLL</TargetDlgDllName>
        <TargetDlgDllArguments>-pCM4</TargetDlgDllArguments>
      </DllOpt>
      <DebugOpt>
        <uSim>0</uSim>
        <uTrg>1</uTrg>
        <sLdApp>1</sLdApp>
        <sGomain>1</sGomain>
        <sRbreak>1</sRbreak>
        <sRwatch>1</sRwatch>
        <sRmem>1</sRmem>
        <sRfunc>1</sRfunc>
        <sRbox>1</sRbox>
        <tLdApp>1</tLdApp>
        <tGomain>1</tGomain>
        <tRbreak>1</tRbreak>
        <tRwatch>1</tRwatch>
        <tRmem>1</tRmem>
        <tRfunc>0</tRfunc>
        <tRbox>1</tRbox>
        <sRunDeb>0</sRunDeb>
        <sLrtime>0</sLrtime>
        <nTsel>7</nTsel>
        <sDll></sDll>
        <sDllPa></sDllPa>
        <sDlgDll></sDlgDll>
        <sDlgPa></sDlgPa>
        <sIfile></sIfile>
        <tDll></tDll>
        <tDllPa></tDllPa>
        <tDlgDll></tDlgDll>
        <tDlgPa></tDlgPa>
        <tIfile></tIfile>
        <pMon>Segger\JL2CM3.dll</pMon>
      </DebugOpt>
      <TargetDriverDllRegistry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>UL2CM3</Key>
          <Name>-O206 -S0 -C0 -FO7 -FD20000000 -FC8000 -FN1 -FS00 -FL040000 -FP0($$Device:EFM32PG12B500F1024GL125$Flash\GECKOP2.FLM)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGTARM</Key>
          <Name>(1010=-1,-1,-1,-1,0)(1007=-1,-1,-1,-1,0)(1008=-1,-1,-1,-1,0)(1009=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ARMDBGFLAGS</Key>
          <Name></Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGUARM</Key>
          <Name>(106=-1,-1,-1,-1,0)(107=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>JL2CM3</Key>
          <Name>-U440000000 -O206 -S0 -A0 -C0 -JU1 -JI127.0.0.1 -JP0 -RST0 -N00("ARM CoreSight SW-DP") -D00(2BA01477) -L00(0) -TO18 -TC10000000 -TP21 -TDS8007 -TDT0 -TDC1F -TIEFFFFFFFF -TIP8 -TB1 -TFE0 -FO7 -FD20000000 -FC8000 -FN1 -FS00 -FL040000 -FP0($$Device:EFM32PG12B500F1024GL125$Flash\GECKOP2.FLM)</Name>
        </SetRegEntry>
      </TargetDriverDllRegistry>
      <DebugFlag>
        <trace>0</trace>
        <periodic>0</periodic>
        <aLwin>1</aLwin>
        <aCover>0</aCover>
        <aSer1>0</aSer1>
        <aSer2>0</aSer2>
        <aPa>0</aPa>
        <viewmode>1</viewmode>
        <vrSel>0</vrSel>
        <aSym>0</aSym>
        <aTbox>0</aTbox>
        <AscS1>0</AscS1>
        <AscS2>0</AscS2>
        <AscS3>0</AscS3>
        <aSer3>0</aSer3>
        <eProf>0</eProf>
        <aLa>0</aLa>
        <aPa1>0</aPa1>
        <AscS4>0</AscS4>
        <aSer4>0</aSer4>
        <StkLoc>0</StkLoc>
        <TrcWin>0</TrcWin>
        <newCpu>2</newCpu>
        <uProt>0</uProt>
      </DebugFlag>
      <LintExecutable></LintExecutable>
      <LintConfigFile></LintConfigFile>
    </TargetOption>
  </Target>
  
        <Group>
          <GroupName>cmsis</GroupName>
          <Files>
            <File>
              <FileName>startup_efm32pg12b.s</FileName>
              <FileType>2</FileType>
              <FilePath>..\..\..\..\..\platform\Device\SiliconLabs\EFM32PG12B\Source\ARM\startup_efm32pg12b.s</FilePath>
            </File>
            <File>
              <FileName>system_efm32pg12b.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\Device\SiliconLabs\EFM32PG12B\Source\system_efm32pg12b.c</FilePath>
            </File>
          </Files>
        </Group>
        <Group>
          <GroupName>mbedtls</GroupName>
          <Files>
            <File>
              <FileName>aes.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\aes.c</FilePath>
            </File>
            <File>
              <FileName>arc4.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\arc4.c</FilePath>
            </File>
            <File>
              <FileName>asn1parse.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\asn1parse.c</FilePath>
            </File>
            <File>
              <FileName>asn1write.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\asn1write.c</FilePath>
            </File>
            <File>
              <FileName>base64.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\base64.c</FilePath>
            </File>
            <File>
              <FileName>bignum.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\bignum.c</FilePath>
            </File>
            <File>
              <FileName>blowfish.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\blowfish.c</FilePath>
            </File>
            <File>
              <FileName>camellia.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\camellia.c</FilePath>
            </File>
            <File>
              <FileName>ccm.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\ccm.c</FilePath>
            </File>
            <File>
              <FileName>cipher.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\cipher.c</FilePath>
            </File>
            <File>
              <FileName>cipher_wrap.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\cipher_wrap.c</FilePath>
            </File>
            <File>
              <FileName>ctr_drbg.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\ctr_drbg.c</FilePath>
            </File>
            <File>
              <FileName>des.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\des.c</FilePath>
            </File>
            <File>
              <FileName>dhm.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\dhm.c</FilePath>
            </File>
            <File>
              <FileName>ecdh.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\ecdh.c</FilePath>
            </File>
            <File>
              <FileName>ecdsa.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\ecdsa.c</FilePath>
            </File>
            <File>
              <FileName>ecp.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\ecp.c</FilePath>
            </File>
            <File>
              <FileName>ecp_curves.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\ecp_curves.c</FilePath>
            </File>
            <File>
              <FileName>entropy.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\entropy.c</FilePath>
            </File>
            <File>
              <FileName>entropy_poll.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\entropy_poll.c</FilePath>
            </File>
            <File>
              <FileName>error.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\error.c</FilePath>
            </File>
            <File>
              <FileName>gcm.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\gcm.c</FilePath>
            </File>
            <File>
              <FileName>havege.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\havege.c</FilePath>
            </File>
            <File>
              <FileName>hmac_drbg.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\hmac_drbg.c</FilePath>
            </File>
            <File>
              <FileName>md.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\md.c</FilePath>
            </File>
            <File>
              <FileName>md2.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\md2.c</FilePath>
            </File>
            <File>
              <FileName>md4.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\md4.c</FilePath>
            </File>
            <File>
              <FileName>md5.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\md5.c</FilePath>
            </File>
            <File>
              <FileName>md_wrap.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\md_wrap.c</FilePath>
            </File>
            <File>
              <FileName>memory_buffer_alloc.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\memory_buffer_alloc.c</FilePath>
            </File>
            <File>
              <FileName>oid.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\oid.c</FilePath>
            </File>
            <File>
              <FileName>pem.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\pem.c</FilePath>
            </File>
            <File>
              <FileName>pk.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\pk.c</FilePath>
            </File>
            <File>
              <FileName>pk_wrap.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\pk_wrap.c</FilePath>
            </File>
            <File>
              <FileName>pkcs12.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\pkcs12.c</FilePath>
            </File>
            <File>
              <FileName>pkcs5.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\pkcs5.c</FilePath>
            </File>
            <File>
              <FileName>pkparse.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\pkparse.c</FilePath>
            </File>
            <File>
              <FileName>pkwrite.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\pkwrite.c</FilePath>
            </File>
            <File>
              <FileName>platform.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\platform.c</FilePath>
            </File>
            <File>
              <FileName>ripemd160.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\ripemd160.c</FilePath>
            </File>
            <File>
              <FileName>rsa.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\rsa.c</FilePath>
            </File>
            <File>
              <FileName>sha1.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\sha1.c</FilePath>
            </File>
            <File>
              <FileName>sha256.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\sha256.c</FilePath>
            </File>
            <File>
              <FileName>sha512.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\sha512.c</FilePath>
            </File>
            <File>
              <FileName>threading.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\threading.c</FilePath>
            </File>
            <File>
              <FileName>timing.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\timing.c</FilePath>
            </File>
            <File>
              <FileName>version.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\version.c</FilePath>
            </File>
            <File>
              <FileName>version_features.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\version_features.c</FilePath>
            </File>
            <File>
              <FileName>xtea.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\library\xtea.c</FilePath>
            </File>
          </Files>
        </Group>
        <Group>
          <GroupName>sl_crypto</GroupName>
          <Files>
            <File>
              <FileName>sl_aes.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\sl_crypto\src\sl_aes.c</FilePath>
            </File>
            <File>
              <FileName>sl_ecp.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\sl_crypto\src\sl_ecp.c</FilePath>
            </File>
            <File>
              <FileName>sl_entropy.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\sl_crypto\src\sl_entropy.c</FilePath>
            </File>
            <File>
              <FileName>sl_sha1.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\sl_crypto\src\sl_sha1.c</FilePath>
            </File>
            <File>
              <FileName>sl_sha256.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\sl_crypto\src\sl_sha256.c</FilePath>
            </File>
            <File>
              <FileName>trng.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\util\third_party\mbedtls\sl_crypto\src\trng.c</FilePath>
            </File>
          </Files>
        </Group>
        <Group>
          <GroupName>emlib</GroupName>
          <Files>
            <File>
              <FileName>em_assert.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emlib\src\em_assert.c</FilePath>
            </File>
            <File>
              <FileName>em_system.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emlib\src\em_system.c</FilePath>
            </File>
            <File>
              <FileName>em_cmu.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emlib\src\em_cmu.c</FilePath>
            </File>
            <File>
              <FileName>em_core.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emlib\src\em_core.c</FilePath>
            </File>
            <File>
              <FileName>em_emu.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emlib\src\em_emu.c</FilePath>
            </File>
            <File>
              <FileName>em_gpio.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emlib\src\em_gpio.c</FilePath>
            </File>
            <File>
              <FileName>em_usart.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emlib\src\em_usart.c</FilePath>
            </File>
            <File>
              <FileName>em_crypto.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emlib\src\em_crypto.c</FilePath>
            </File>
          </Files>
        </Group>
        <Group>
          <GroupName>Drivers</GroupName>
          <Files>
            <File>
              <FileName>retargetio.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\hardware\kit\common\drivers\retargetio.c</FilePath>
            </File>
            <File>
              <FileName>retargetserial.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\hardware\kit\common\drivers\retargetserial.c</FilePath>
            </File>
          </Files>
        </Group>
        <Group>
          <GroupName>test</GroupName>
          <Files>
            <File>
              <FileName>main.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\main.c</FilePath>
            </File>
          </Files>
        </Group>

</ProjectOpt>
