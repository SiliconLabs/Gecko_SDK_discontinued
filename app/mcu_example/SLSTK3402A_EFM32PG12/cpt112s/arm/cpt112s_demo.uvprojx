# Keil uVision project cpt112s_demo.uvprojx, settings and files
target cpt112s_demo (ARM-ADS)
  device: EFM32PG12B500F1024GL125 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(38400000) CPUTYPE("Cortex-M4") FPU2
  output: cpt112s_demo
  AfterMake: fromelf.exe --bin --output obj\cpt112s_demo.bin obj\cpt112s_demo.axf
  c flags: Optim=4 oTime=1 uC99=1 wLevel=2
  c define: EFM32PG12B500F1024GL125 DEBUG_EFM
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32PG12B\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\SLSTK3402A_EFM32PG12\config;..\..\..\..\..\platform\middleware\glib;..\..\..\..\..\platform\middleware\glib\dmd;..\..\..\..\..\platform\middleware\glib\dmd\ssd2119;..\..\..\..\..\platform\middleware\glib\glib;..;..\Drivers;..\img
  asm define: EFM32PG12B500F1024GL125 DEBUG_EFM
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32PG12B/Source/ARM/: startup_efm32pg12b.s
    ../../../../../platform/Device/SiliconLabs/EFM32PG12B/Source/: system_efm32pg12b.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: cpt112s_i2c.c display.c displayls013b7dh03.c displaypalemlib.c udelay.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_emu.c em_gpio.c em_i2c.c em_prs.c em_rtcc.c em_system.c em_usart.c
  group img
    ../img/: circle.xbm out_disable.xbm out_on.xbm out_off.xbm
  group Source
    ../: cpt112s_demo.c displayconfigapp.h
    ../Drivers/: render.c render.h lcd.c lcd.h
