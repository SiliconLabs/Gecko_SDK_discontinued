# IAR project rtx_blink.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32PG12B500F1024GL125 SiliconLaboratories EFM32PG12B500F1024GL125
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32PG12B500F1024GL125
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32PG12B\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\util\third_party\keil_rtx\Inc; ..\..\..\..\..\hardware\kit\SLSTK3402A_EFM32PG12\config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: EFM32PG12B500F1024GL125
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: rtx_blink.bin
  ILINK.IlinkOutputFile: rtx_blink.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\util\third_party\keil_rtx\LIB\IAR\RTX_CM4.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32PG12B500F1024GL125
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32PG12B/Source/IAR/: startup_efm32pg12b.s
    ../../../../../platform/Device/SiliconLabs/EFM32PG12B/Source/: system_efm32pg12b.c
  group BSP
    ../../../../../hardware/kit/common/bsp/: bsp_stk_leds.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_system.c
  group Source
    ../: rtx_blink.c RTX_Conf_CM.c
