# Keil uVision project preamp.uvprojx, settings and files
target preamp (ARM-ADS)
  device: EFM32LG990F256 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: preamp
  AfterMake: fromelf.exe --bin --output obj\preamp.bin obj\preamp.axf
  c flags: Optim=4 oTime=1
  c define: EFM32LG990F256 DEBUG_EFM
  c misc: --c99
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32LG\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\EFM32LG_DK3650\config;..\..\..\..\..\platform\emdrv\common\inc;..\..\..\..\..\platform\emdrv\rtcdrv\inc;..
  asm define: EFM32LG990F256 DEBUG_EFM
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32LG/Source/ARM/: startup_efm32lg.s
    ../../../../../platform/Device/SiliconLabs/EFM32LG/Source/: system_efm32lg.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_dk_3201.c bsp_dk_leds.c bsp_trace.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: dmactrl.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_adc.c em_cmu.c em_core.c em_dac.c em_dma.c em_emu.c em_ebi.c em_gpio.c em_prs.c em_rtc.c em_system.c em_timer.c em_usart.c
  group emdrv
    ../../../../../platform/emdrv/rtcdrv/src/: rtcdriver.c
  group Source
    ../: preamp.c
