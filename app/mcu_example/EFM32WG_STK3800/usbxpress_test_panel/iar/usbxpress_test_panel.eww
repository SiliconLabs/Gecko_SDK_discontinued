<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\usbxpress_test_panel.ewp</path>
  </project>

  <batchBuild/>
</workspace>
