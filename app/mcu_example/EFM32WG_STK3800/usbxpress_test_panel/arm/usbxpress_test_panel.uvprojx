# Keil uVision project usbxpress_test_panel.uvprojx, settings and files
target usbxpress_test_panel (ARM-ADS)
  device: EFM32WG990F256 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(48000000) CPUTYPE("Cortex-M4") FPU2
  output: usbxpress_test_panel
  AfterMake: fromelf.exe --bin --output obj\usbxpress_test_panel.bin obj\usbxpress_test_panel.axf
  c flags: Optim=1
  c define: EFM32WG990F256 DEBUG_EFM_USER
  c misc: --c99
  c include: ..\;..;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32WG\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\platform\middleware\usb_gecko\inc;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\EFM32WG_STK3800\config;..\..\..\..\..\platform\middleware\usbxpress\inc
  asm define: EFM32WG990F256 DEBUG_EFM_USER
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32WG/Source/ARM/: startup_efm32wg.s
    ../../../../../platform/Device/SiliconLabs/EFM32WG/Source/: system_efm32wg.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: segmentlcd.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_ebi.c em_emu.c em_gpio.c em_lcd.c em_system.c em_timer.c em_usart.c
  group emusb
    ../../../../../platform/middleware/usb_gecko/src/: em_usbd.c em_usbdch9.c em_usbhal.c em_usbdep.c em_usbdint.c em_usbtimer.c
  group emusbxpress
    ../../../../../platform/middleware/usbxpress/src/: em_usbxpress.c em_usbxpress_callback.c em_usbxpress_descriptors.c
  group Source
    ../: main.c
