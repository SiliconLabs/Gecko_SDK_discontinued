# IAR project ucos2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32WG990F256 SiliconLaboratories EFM32WG990F256
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32WG990F256
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32WG\Include; ..\..\..\..\..\platform\emlib\inc; ..\src\bsp; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\EFM32WG_STK3800\config; ..\src\app; ..\..\..\..\..\util\third_party\micrium\uCOS-II\uC-CPU; ..\..\..\..\..\util\third_party\micrium\uCOS-II\uC-LIB; ..\..\..\..\..\util\third_party\micrium\uCOS-II\uCOS-II\Source; ..\..\..\..\..\util\third_party\micrium\uCOS-II\uC-CPU\ARM-Cortex-M4\IAR; ..\..\..\..\..\util\third_party\micrium\uCOS-II\uCOS-II\Ports\ARM-Cortex-M\ARMv7-M\IAR
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: EFM32WG990F256
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ucos2.bin
  ILINK.IlinkOutputFile: ucos2.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32WG990F256
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group APP
    ../src/app/: app.c app_hooks.c app_task_one.c app_task_two.c app_task_three.c
  group BSP
    ../src/bsp/: bspos.c
    ../../../../../hardware/kit/common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32WG/Source/IAR/: startup_efm32wg.s
    ../../../../../platform/Device/SiliconLabs/EFM32WG/Source/: system_efm32wg.c
    ../../../../../util/third_party/micrium/Ports/CMSIS/IAR/: cmsis_wrapper.s
  group Drivers
    ../../../../../hardware/kit/common/drivers/: retargetio.c retargetserial.c segmentlcd.c
  group emlib
    ../../../../../platform/emlib/src/: em_cmu.c em_core.c em_ebi.c em_emu.c em_gpio.c em_lcd.c em_system.c em_usart.c em_leuart.c
  group uC/CPU
    ../../../../../util/third_party/micrium/uCOS-II/uC-CPU/: cpu_core.c
    ../../../../../util/third_party/micrium/uCOS-II/uC-CPU/ARM-Cortex-M4/IAR/: cpu_c.c cpu_a.asm
  group uC/LIB
    ../../../../../util/third_party/micrium/uCOS-II/uC-LIB/Ports/ARM-Cortex-M4/IAR/: lib_mem_a.asm
  group uC/OS-II
    ../../../../../util/third_party/micrium/uCOS-II/uCOS-II/Source/: ucos_ii.c
    ../../../../../util/third_party/micrium/uCOS-II/uCOS-II/Ports/ARM-Cortex-M/ARMv7-M/IAR/: os_dbg.c os_cpu_c.c os_cpu_a.asm
