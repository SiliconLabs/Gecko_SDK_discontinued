# Keil uVision project ucos2.uvprojx, settings and files
target ucos2 (ARM-ADS)
  device: EFM32WG990F256 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(48000000) CPUTYPE("Cortex-M4") FPU2
  output: ucos2
  AfterMake: fromelf.exe --bin --output obj\ucos2.bin obj\ucos2.axf
  c flags: Optim=1 oTime=1
  c define: EFM32WG990F256
  c misc: --c99
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32WG\Include;..\..\..\..\..\platform\emlib\inc;..\src\bsp;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\EFM32WG_STK3800\config;..\src\app;..\..\..\..\..\util\third_party\micrium\uCOS-II\uC-CPU;..\..\..\..\..\util\third_party\micrium\uCOS-II\uC-LIB;..\..\..\..\..\util\third_party\micrium\uCOS-II\uCOS-II\Source;..\..\..\..\..\util\third_party\micrium\uCOS-II\uC-CPU\ARM-Cortex-M4\RealView;..\..\..\..\..\util\third_party\micrium\uCOS-II\uCOS-II\Ports\ARM-Cortex-M\ARMv7-M\ARM
  asm define: EFM32WG990F256
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ../src/app/: app.c app_hooks.c app_task_one.c app_task_two.c app_task_three.c
  group BSP
    ../src/bsp/: bspos.c
    ../../../../../hardware/kit/common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32WG/Source/ARM/: startup_efm32wg.s
    ../../../../../platform/Device/SiliconLabs/EFM32WG/Source/: system_efm32wg.c
    ../../../../../util/third_party/micrium/Ports/CMSIS/ARM/: cmsis_wrapper.s
  group Drivers
    ../../../../../hardware/kit/common/drivers/: retargetio.c retargetserial.c segmentlcd.c
  group emlib
    ../../../../../platform/emlib/src/: em_cmu.c em_core.c em_ebi.c em_emu.c em_gpio.c em_lcd.c em_system.c em_usart.c em_leuart.c
  group uC/CPU
    ../../../../../util/third_party/micrium/uCOS-II/uC-CPU/: cpu_core.c
    ../../../../../util/third_party/micrium/uCOS-II/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
  group uC/LIB
    ../../../../../util/third_party/micrium/uCOS-II/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uC/OS-II
    ../../../../../util/third_party/micrium/uCOS-II/uCOS-II/Source/: ucos_ii.c
    ../../../../../util/third_party/micrium/uCOS-II/uCOS-II/Ports/ARM-Cortex-M/ARMv7-M/ARM/: os_dbg.c os_cpu_c.c os_cpu_a.asm
