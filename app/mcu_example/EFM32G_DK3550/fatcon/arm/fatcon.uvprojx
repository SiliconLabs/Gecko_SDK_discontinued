# Keil uVision project fatcon.uvprojx, settings and files
target fatcon (ARM-ADS)
  device: EFM32G890F128 Silicon Labs
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(14000000) CPUTYPE("Cortex-M3")
  output: fatcon
  AfterMake: fromelf.exe --bin --output obj\fatcon.bin obj\fatcon.axf
  c flags: Optim=1
  c define: EFM32G890F128 DEBUG_EFM
  c misc: --c99
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32G\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\EFM32G_DK3550\config;..\..\..\..\..\util\third_party\fatfs\inc
  asm define: EFM32G890F128 DEBUG_EFM
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_dk_3201.c bsp_trace.c
  group drivers
    ../../../../../hardware/kit/common/drivers/: retargetio.c retargetserial.c microsd.c
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32G/Source/ARM/: startup_efm32g.s
    ../../../../../platform/Device/SiliconLabs/EFM32G/Source/: system_efm32g.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_ebi.c em_emu.c em_gpio.c em_system.c em_usart.c
  group FatFS
    ../../../../../util/third_party/fatfs/src/: diskio.c ff.c
  group Source
    ../: fatcon.c
