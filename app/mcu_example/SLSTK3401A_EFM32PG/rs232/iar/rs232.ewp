# IAR project rs232.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32PG1B200F256GM48 SiliconLaboratories EFM32PG1B200F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32PG1B200F256GM48; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32PG1B\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\hardware\kit\SLSTK3401A_EFM32PG\config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: EFM32PG1B200F256GM48; DEBUG_EFM
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: rs232.bin
  ILINK.IlinkOutputFile: rs232.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32PG1B200F256GM48; DEBUG_EFM
  group Drivers
    ../../../../../hardware/kit/common/drivers/: retargetio.c retargetserial.c
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32PG1B/Source/IAR/: startup_efm32pg1b.s
    ../../../../../platform/Device/SiliconLabs/EFM32PG1B/Source/: system_efm32pg1b.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_system.c em_cmu.c em_core.c em_emu.c em_gpio.c em_usart.c em_leuart.c
  group Source
    ../: main.c
