<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ezradio_trx_ack.ewp</path>
  </project>

  <batchBuild/>
</workspace>
