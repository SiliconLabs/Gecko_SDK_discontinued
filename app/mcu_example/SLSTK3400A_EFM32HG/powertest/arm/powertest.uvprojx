# Keil uVision project powertest.uvprojx, settings and files
target powertest (ARM-ADS)
  device: EFM32HG322F64 Silicon Labs
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(24000000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: powertest
  AfterMake: fromelf.exe --bin --output obj\powertest.bin obj\powertest.axf
  c flags: Optim=4 oTime=1
  c define: EFM32HG322F64 DEBUG_EFM
  c misc: --c99
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32HG\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\SLSTK3400A_EFM32HG\config;..\..\..\..\..\platform\emdrv\common\inc;..\..\..\..\..\platform\emdrv\rtcdrv\inc;..
  asm define: EFM32HG322F64 DEBUG_EFM
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32HG/Source/ARM/: startup_efm32hg.s
    ../../../../../platform/Device/SiliconLabs/EFM32HG/Source/: system_efm32hg.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_emu.c em_system.c em_rtc.c em_wdog.c
  group emdrv
    ../../../../../platform/emdrv/rtcdrv/src/: rtcdriver.c
  group Source
    ../: main.c
