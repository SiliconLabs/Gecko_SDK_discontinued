# Keil uVision project clock.uvprojx, settings and files
target clock (ARM-ADS)
  device: EFM32HG322F64 Silicon Labs
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(24000000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: clock
  AfterMake: fromelf.exe --bin --output obj\clock.bin obj\clock.axf
  c flags: Optim=4
  c define: EFM32HG322F64 GLIB_NO_DEFAULT_FONT
  c misc: --c99
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32HG\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\platform\middleware\glib;..\..\..\..\..\platform\middleware\glib\dmd;..\..\..\..\..\platform\middleware\glib\glib;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\SLSTK3400A_EFM32HG\config;..
  asm define: EFM32HG322F64 GLIB_NO_DEFAULT_FONT
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32HG/Source/ARM/: startup_efm32hg.s
    ../../../../../platform/Device/SiliconLabs/EFM32HG/Source/: system_efm32hg.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: display.c displayls013b7dh03.c displaypalemlib.c retargetio.c retargettextdisplay.c textdisplay.c udelay.c
  group glib
    ../../../../../platform/middleware/glib/dmd/display/: dmd_display.c
    ../../../../../platform/middleware/glib/glib/: glib.c glib_bitmap.c glib_circle.c glib_line.c glib_rectangle.c glib_string.c glib_font_narrow_6x8.c glib_font_number_16x20.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_emu.c em_gpio.c em_pcnt.c em_prs.c em_rtc.c em_system.c em_usart.c
  group Source
    ../: main.c analog_clock.c
