# Keil uVision project rtx_tickless.uvprojx, settings and files
target rtx_tickless (ARM-ADS)
  device: EFM32ZG222F32 Silicon Labs
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(24000000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: rtx_tickless
  AfterMake: fromelf.exe --bin --output obj\rtx_tickless.bin obj\rtx_tickless.axf
  c flags: Optim=4 oTime=1
  c define: EFM32ZG222F32
  c misc: --c99
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32ZG\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\util\third_party\keil_rtx\INC;..\..\..\..\..\platform\middleware\glib;..\..\..\..\..\hardware\kit\EFM32ZG_STK3200\config;..
  asm define: EFM32ZG222F32
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32ZG/Source/ARM/: startup_efm32zg.s
    ../../../../../platform/Device/SiliconLabs/EFM32ZG/Source/: system_efm32zg.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: display.c displayls013b7dh03.c displaypalemlib.c udelay.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_emu.c em_gpio.c em_lcd.c em_rtc.c em_system.c em_usart.c
  group Source
    ../: rtx_tickless.c RTX_Conf_CM.c
  group Libraries
    ../../../../../util/third_party/keil_rtx/LIB/ARM/: RTX_CM0.lib
