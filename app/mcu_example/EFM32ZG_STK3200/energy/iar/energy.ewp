# IAR project energy.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32ZG222F32 SiliconLaboratories EFM32ZG222F32
  ICCARM.CCDefines: EFM32ZG222F32; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32ZG\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\EFM32ZG_STK3200\config; ..; ..\..\..\..\..\platform\middleware\glib
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: EFM32ZG222F32; DEBUG_EFM
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: energy.bin
  ILINK.IlinkOutputFile: energy.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32ZG222F32; DEBUG_EFM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32ZG/Source/IAR/: startup_efm32zg.s
    ../../../../../platform/Device/SiliconLabs/EFM32ZG/Source/: system_efm32zg.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: udelay.c retargetio.c retargettextdisplay.c textdisplay.c display.c displaypalemlib.c displayls013b7dh03.c
  group BSP
    ../../../../../hardware/kit/common/bsp/: bsp_bcc.c bsp_stk.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_emu.c em_gpio.c em_leuart.c em_prs.c em_rtc.c em_timer.c em_usart.c
  group Source
    ../: main.c
