# Keil uVision project usbdcomposite.uvprojx, settings and files
target usbdcomposite (ARM-ADS)
  device: EFM32WG990F256 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(48000000) CPUTYPE("Cortex-M4") FPU2
  output: usbdcomposite
  AfterMake: fromelf.exe --bin --output obj\usbdcomposite.bin obj\usbdcomposite.axf
  c flags: Optim=1
  c define: EFM32WG990F256 DEBUG_EFM_USER
  c misc: --c99
  c include: ..\;..;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32WG\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\platform\middleware\usb_gecko\inc;..\..\..\..\..\util\third_party\fatfs\inc;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\EFM32WG_DK3850\config
  asm define: EFM32WG990F256 DEBUG_EFM_USER
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32WG/Source/ARM/: startup_efm32wg.s
    ../../../../../platform/Device/SiliconLabs/EFM32WG/Source/: system_efm32wg.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_dk_3201.c bsp_dk_leds.c bsp_trace.c
  group FatFS
    ../../../../../util/third_party/fatfs/src/: diskio.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_msc.c em_system.c em_timer.c em_usart.c
  group emusb
    ../../../../../platform/middleware/usb_gecko/src/: em_usbd.c em_usbdch9.c em_usbhal.c em_usbdep.c em_usbdint.c em_usbtimer.c
  group Source
    ../: main.c descriptors.c vud.c msddmedia.c
  group drivers
    ../../../../../hardware/kit/common/drivers/: cdc.c msdd.c norflash.c microsd.c dmactrl.c
