# Keil uVision project usbdtouch.uvprojx, settings and files
target usbdtouch (ARM-ADS)
  device: EFM32WG990F256 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(48000000) CPUTYPE("Cortex-M4") FPU2
  output: usbdtouch
  AfterMake: fromelf.exe --bin --output obj\usbdtouch.bin obj\usbdtouch.axf
  c flags: Optim=1
  c define: EFM32WG990F256 DEBUG_EFM __HEAP_SIZE=0x800 __STACK_SIZE=0x1000
  c misc: --c99
  c include: ..\;..;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32WG\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\platform\middleware\usb_gecko\inc;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\EFM32WG_DK3850\config;..\..\..\..\..\util\third_party\fatfs\inc;..\..\..\..\..\platform\middleware\glib
  asm define: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_dk_3201.c bsp_dk_leds.c bsp_trace.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: calibrate.c eeprom.c i2cspm.c msdd.c norflash.c retargetio.c retargetserial.c tftspi.c touch.c tftdirect.c
  group graphics
    ../../../../../platform/middleware/glib/dmd/ssd2119/: dmd_ssd2119_direct.c
  group CMSIS
    ../: startup_efm32_keil.s
    ../../../../../platform/Device/SiliconLabs/EFM32WG/Source/: system_efm32wg.c
  group emlib
    ../../../../../platform/emlib/src/: em_adc.c em_assert.c em_cmu.c em_core.c em_ebi.c em_emu.c em_gpio.c em_i2c.c em_system.c em_timer.c em_usart.c
  group emusb
    ../../../../../platform/middleware/usb_gecko/src/: em_usbd.c em_usbdch9.c em_usbhal.c em_usbdep.c em_usbdint.c em_usbtimer.c
  group fatfs
    ../../../../../util/third_party/fatfs/src/: ff.c
  group Source
    ../: main.c fnt16x28.c bitmap.c msddmedia.c descriptors.c
