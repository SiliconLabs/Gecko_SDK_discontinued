<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\audiofft_softfloat.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\audiofft_hardfloat.ewp</path>
  </project>

  <batchBuild/>
</workspace>
