<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectOpt xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_opt.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <Extensions>
    <cExt>*.c</cExt>
    <aExt>*.s*; *.src; *.a*</aExt>
    <oExt>*.obj</oExt>
    <lExt>*.lib</lExt>
    <tExt>*.txt; *.h; *.inc</tExt>
    <pExt>*.plm</pExt>
    <CppX>*.cpp</CppX>
  </Extensions>

  <DaveTm>
    <dwLowDateTime>0</dwLowDateTime>
    <dwHighDateTime>0</dwHighDateTime>
  </DaveTm>

  <Target>
    <TargetName>ezradio_per</TargetName>
    <ToolsetNumber>0x4</ToolsetNumber>
    <ToolsetName>ARM-ADS</ToolsetName>
    <TargetOption>
      <CLKADS>24000000</CLKADS>
      <OPTTT>
        <gFlags>1</gFlags>
        <BeepAtEnd>1</BeepAtEnd>
        <RunSim>1</RunSim>
        <RunTarget>0</RunTarget>
      </OPTTT>
      <OPTHX>
        <HexSelection>1</HexSelection>
        <FlashByte>65535</FlashByte>
        <HexRangeLowAddress>0</HexRangeLowAddress>
        <HexRangeHighAddress>0</HexRangeHighAddress>
        <HexOffset>0</HexOffset>
      </OPTHX>
      <OPTLEX>
        <PageWidth>79</PageWidth>
        <PageLength>66</PageLength>
        <TabStop>8</TabStop>
        <ListingPath>.\lst\</ListingPath>
      </OPTLEX>
      <ListingPage>
        <CreateCListing>1</CreateCListing>
        <CreateAListing>1</CreateAListing>
        <CreateLListing>1</CreateLListing>
        <CreateIListing>0</CreateIListing>
        <AsmCond>1</AsmCond>
        <AsmSymb>1</AsmSymb>
        <AsmXref>0</AsmXref>
        <CCond>1</CCond>
        <CCode>0</CCode>
        <CListInc>0</CListInc>
        <CSymb>0</CSymb>
        <LinkerCodeListing>0</LinkerCodeListing>
      </ListingPage>
      <OPTXL>
        <LMap>1</LMap>
        <LComments>1</LComments>
        <LGenerateSymbols>1</LGenerateSymbols>
        <LLibSym>1</LLibSym>
        <LLines>1</LLines>
        <LLocSym>1</LLocSym>
        <LPubSym>1</LPubSym>
        <LXref>0</LXref>
        <LExpSel>0</LExpSel>
      </OPTXL>
      <OPTFL>
        <tvExp>1</tvExp>
        <tvExpOptDlg>0</tvExpOptDlg>
        <IsCurrentTarget>1</IsCurrentTarget>
      </OPTFL>
      <CpuCode>0</CpuCode>
      <DllOpt>
        <SimDllName>SARMCM3.DLL</SimDllName>
        <SimDllArguments></SimDllArguments>
        <SimDlgDllName>DCM.DLL</SimDlgDllName>
        <SimDlgDllArguments>-pCM0+</SimDlgDllArguments>
        <TargetDllName>SARMCM3.DLL</TargetDllName>
        <TargetDllArguments></TargetDllArguments>
        <TargetDlgDllName>TCM.DLL</TargetDlgDllName>
        <TargetDlgDllArguments>-pCM0+</TargetDlgDllArguments>
      </DllOpt>
      <DebugOpt>
        <uSim>0</uSim>
        <uTrg>1</uTrg>
        <sLdApp>1</sLdApp>
        <sGomain>1</sGomain>
        <sRbreak>1</sRbreak>
        <sRwatch>1</sRwatch>
        <sRmem>1</sRmem>
        <sRfunc>1</sRfunc>
        <sRbox>1</sRbox>
        <tLdApp>1</tLdApp>
        <tGomain>1</tGomain>
        <tRbreak>1</tRbreak>
        <tRwatch>1</tRwatch>
        <tRmem>1</tRmem>
        <tRfunc>0</tRfunc>
        <tRbox>1</tRbox>
        <tRtrace>0</tRtrace>
        <sRunDeb>0</sRunDeb>
        <sLrtime>0</sLrtime>
        <nTsel>7</nTsel>
        <sDll></sDll>
        <sDllPa></sDllPa>
        <sDlgDll></sDlgDll>
        <sDlgPa></sDlgPa>
        <sIfile></sIfile>
        <tDll></tDll>
        <tDllPa></tDllPa>
        <tDlgDll></tDlgDll>
        <tDlgPa></tDlgPa>
        <tIfile></tIfile>
        <pMon>Segger\JL2CM3.dll</pMon>
      </DebugOpt>
      <TargetDriverDllRegistry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>JL2CM3</Key>
          <Name>-U174200321 -O78 -S0 -A0 -C0 -JU1 -JI127.0.0.1 -JP0 -RST0 -N00("ARM CoreSight SW-DP") -D00(2BA01477) -L00(0) -TO18 -TC10000000 -TP21 -TDS8007 -TDT0 -TDC1F -TIEFFFFFFFF -TIP8 -TB1 -TFE0 -FO7 -FD20000000 -FC1000 -FN1 -FS00 -FL08000 -FP0($$Device:EZR32HG320F64R55$Flash\EFM32M0P.FLM)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>UL2CM3</Key>
          <Name>UL2CM3(-S0 -C0 -P0 -FD20000000 -FC1000 -FN1 -FS00 -FL08000 -FP0($$Device:EZR32HG320F64R55$Flash\EFM32M0P.FLM)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGTARM</Key>
          <Name>(1010=-1,-1,-1,-1,0)(1007=-1,-1,-1,-1,0)(1008=-1,-1,-1,-1,0)(1009=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ARMDBGFLAGS</Key>
          <Name></Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGUARM</Key>
          <Name>(106=-1,-1,-1,-1,0)(107=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
      </TargetDriverDllRegistry>
      <Breakpoint/>
      <Tracepoint>
        <THDelay>0</THDelay>
      </Tracepoint>
      <DebugFlag>
        <trace>0</trace>
        <periodic>0</periodic>
        <aLwin>1</aLwin>
        <aCover>0</aCover>
        <aSer1>0</aSer1>
        <aSer2>0</aSer2>
        <aPa>0</aPa>
        <viewmode>1</viewmode>
        <vrSel>0</vrSel>
        <aSym>0</aSym>
        <aTbox>0</aTbox>
        <AscS1>0</AscS1>
        <AscS2>0</AscS2>
        <AscS3>0</AscS3>
        <aSer3>0</aSer3>
        <eProf>0</eProf>
        <aLa>0</aLa>
        <aPa1>0</aPa1>
        <AscS4>0</AscS4>
        <aSer4>0</aSer4>
        <StkLoc>0</StkLoc>
        <TrcWin>0</TrcWin>
        <newCpu>0</newCpu>
        <uProt>0</uProt>
      </DebugFlag>
      <LintExecutable></LintExecutable>
      <LintConfigFile></LintConfigFile>
    </TargetOption>
  </Target>
  
        <Group>
          <GroupName>CMSIS</GroupName>
          <Files>
            <File>
              <FileName>startup_ezr32hg.s</FileName>
              <FileType>2</FileType>
              <FilePath>..\..\..\..\..\platform\Device\SiliconLabs\EZR32HG\Source\ARM\startup_ezr32hg.s</FilePath>
            </File>
            <File>
              <FileName>system_ezr32hg.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\Device\SiliconLabs\EZR32HG\Source\system_ezr32hg.c</FilePath>
            </File>
          </Files>
        </Group>
        <Group>
          <GroupName>Drivers</GroupName>
          <Files>
            <File>
              <FileName>display.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\hardware\kit\common\drivers\display.c</FilePath>
            </File>
            <File>
              <FileName>displayls013b7dh03.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\hardware\kit\common\drivers\displayls013b7dh03.c</FilePath>
            </File>
            <File>
              <FileName>displaypalemlib.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\hardware\kit\common\drivers\displaypalemlib.c</FilePath>
            </File>
            <File>
              <FileName>dmactrl.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\hardware\kit\common\drivers\dmactrl.c</FilePath>
            </File>
            <File>
              <FileName>retargetio.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\hardware\kit\common\drivers\retargetio.c</FilePath>
            </File>
            <File>
              <FileName>retargettextdisplay.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\hardware\kit\common\drivers\retargettextdisplay.c</FilePath>
            </File>
            <File>
              <FileName>textdisplay.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\hardware\kit\common\drivers\textdisplay.c</FilePath>
            </File>
            <File>
              <FileName>udelay.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\hardware\kit\common\drivers\udelay.c</FilePath>
            </File>
          </Files>
        </Group>
        <Group>
          <GroupName>dmadrv</GroupName>
          <Files>
            <File>
              <FileName>dmadrv.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emdrv\dmadrv\src\dmadrv.c</FilePath>
            </File>
          </Files>
        </Group>
        <Group>
          <GroupName>ezradiodrv</GroupName>
          <Files>
            <File>
              <FileName>ezradio_api_lib.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emdrv\ezradiodrv\common\src\ezradio_api_lib.c</FilePath>
            </File>
            <File>
              <FileName>ezradio_comm.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emdrv\ezradiodrv\common\src\ezradio_comm.c</FilePath>
            </File>
            <File>
              <FileName>ezradio_hal.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emdrv\ezradiodrv\common\src\ezradio_hal.c</FilePath>
            </File>
            <File>
              <FileName>ezradio_api_lib_add.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emdrv\ezradiodrv\common\src\si4x55\ezradio_api_lib_add.c</FilePath>
            </File>
            <File>
              <FileName>ezradio_plugin_manager.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emdrv\ezradiodrv\plugins\src\ezradio_plugin_manager.c</FilePath>
            </File>
            <File>
              <FileName>ezradio_transmit_plugin.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emdrv\ezradiodrv\plugins\src\ezradio_transmit_plugin.c</FilePath>
            </File>
            <File>
              <FileName>ezradio_receive_plugin.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emdrv\ezradiodrv\plugins\src\ezradio_receive_plugin.c</FilePath>
            </File>
            <File>
              <FileName>ezradio_crcerror_plugin.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emdrv\ezradiodrv\plugins\src\ezradio_crcerror_plugin.c</FilePath>
            </File>
            <File>
              <FileName>ezradio_auto_ack_plugin.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emdrv\ezradiodrv\plugins\src\ezradio_auto_ack_plugin.c</FilePath>
            </File>
            <File>
              <FileName>ezradio_unmod_carrier_plugin.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emdrv\ezradiodrv\plugins\src\ezradio_unmod_carrier_plugin.c</FilePath>
            </File>
            <File>
              <FileName>ezradio_pn9_plugin.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emdrv\ezradiodrv\plugins\src\ezradio_pn9_plugin.c</FilePath>
            </File>
            <File>
              <FileName>ezradio_direct_transmit_plugin.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emdrv\ezradiodrv\plugins\src\ezradio_direct_transmit_plugin.c</FilePath>
            </File>
            <File>
              <FileName>ezradio_direct_receive_plugin.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emdrv\ezradiodrv\plugins\src\ezradio_direct_receive_plugin.c</FilePath>
            </File>
          </Files>
        </Group>
        <Group>
          <GroupName>gpiointerrupt</GroupName>
          <Files>
            <File>
              <FileName>gpiointerrupt.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emdrv\gpiointerrupt\src\gpiointerrupt.c</FilePath>
            </File>
          </Files>
        </Group>
        <Group>
          <GroupName>rtcdrv</GroupName>
          <Files>
            <File>
              <FileName>rtcdriver.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emdrv\rtcdrv\src\rtcdriver.c</FilePath>
            </File>
          </Files>
        </Group>
        <Group>
          <GroupName>spidrv</GroupName>
          <Files>
            <File>
              <FileName>spidrv.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emdrv\spidrv\src\spidrv.c</FilePath>
            </File>
          </Files>
        </Group>
        <Group>
          <GroupName>ustimer</GroupName>
          <Files>
            <File>
              <FileName>ustimer.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emdrv\ustimer\src\ustimer.c</FilePath>
            </File>
          </Files>
        </Group>
        <Group>
          <GroupName>emlib</GroupName>
          <Files>
            <File>
              <FileName>em_assert.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emlib\src\em_assert.c</FilePath>
            </File>
            <File>
              <FileName>em_cmu.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emlib\src\em_cmu.c</FilePath>
            </File>
            <File>
              <FileName>em_core.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emlib\src\em_core.c</FilePath>
            </File>
            <File>
              <FileName>em_emu.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emlib\src\em_emu.c</FilePath>
            </File>
            <File>
              <FileName>em_dma.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emlib\src\em_dma.c</FilePath>
            </File>
            <File>
              <FileName>em_gpio.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emlib\src\em_gpio.c</FilePath>
            </File>
            <File>
              <FileName>em_pcnt.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emlib\src\em_pcnt.c</FilePath>
            </File>
            <File>
              <FileName>em_prs.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emlib\src\em_prs.c</FilePath>
            </File>
            <File>
              <FileName>em_rtc.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emlib\src\em_rtc.c</FilePath>
            </File>
            <File>
              <FileName>em_system.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emlib\src\em_system.c</FilePath>
            </File>
            <File>
              <FileName>em_timer.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emlib\src\em_timer.c</FilePath>
            </File>
            <File>
              <FileName>em_usart.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\..\..\..\..\platform\emlib\src\em_usart.c</FilePath>
            </File>
          </Files>
        </Group>
        <Group>
          <GroupName>Source</GroupName>
          <Files>
            <File>
              <FileName>main.c</FileName>
              <FileType>1</FileType>
              <FilePath>..\main.c</FilePath>
            </File>
          </Files>
        </Group>
        <Group>
          <GroupName>RadioConfig</GroupName>
          <Files>
          </Files>
        </Group>

</ProjectOpt>
