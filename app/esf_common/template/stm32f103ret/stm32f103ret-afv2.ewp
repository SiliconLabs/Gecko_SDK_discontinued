# IAR project stm32f103ret-afv2.ewp, settings and files
configuration Normal (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  ICCARM.CCDefines: EMBER_SERIAL_USE_STDIO; EZSP_HOST; HAL_HOST; STM32F10X_HD; USE_STDPERIPH_DRIVER; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/$--deviceName--$/$--deviceName--$_endpoint_config.h"; BOARD_HEADER="$--boardHeader--$"; CONFIGURATION_HEADER="app/framework/util/config.h"; PLATFORM_HEADER="$--halDirFromStackFs--$/host/cortexm3/stm32f103ret/compiler/iar-st.h"; ZA_GENERATED_HEADER="app/builder/$--deviceName--$/$--deviceName--$.h"; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; $--stackDirFromProjBs--$; $--frameworkDirFromProjBs--$; $--frameworkDirFromProjBs--$\..\..; $--frameworkDirFromProjBs--$\..\..\stack; $--frameworkDirFromProjBs--$\..\util; $--frameworkDirFromProjBs--$\include; $--halDirFromProjBs--$; $--halDirFromProjBs--$\plugin; $--halDirFromProjBs--$\..; $--halDirFromProjBs--$\host\cortexm3\stm32f103ret; $--halDirFromProjBs--$\host\cortexm3\stm32f103ret\Libraries\CMSIS\CM3\CoreSupport; $--halDirFromProjBs--$\host\cortexm3\stm32f103ret\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; $--halDirFromProjBs--$\host\cortexm3\stm32f103ret\Libraries\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: EMBER_SERIAL_USE_STDIO; EZSP_HOST; HAL_HOST; STM32F10X_HD; USE_STDPERIPH_DRIVER; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/$--deviceName--$/$--deviceName--$_endpoint_config.h"; BOARD_HEADER="$--boardHeader--$"; CONFIGURATION_HEADER="app/framework/util/config.h"; PLATFORM_HEADER="$--halDirFromStackFs--$/host/cortexm3/stm32f103ret/compiler/iar-st.h"; ZA_GENERATED_HEADER="app/builder/$--deviceName--$/$--deviceName--$.h"
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: $--deviceName--$.s37
  ILINK.IlinkOutputFile: $--deviceName--$.out
  ILINK.IlinkIcfFile: $--halDirFromProjBs--$\host\cortexm3\stm32f103ret\iar-cfg-st.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: afv2-bookkeeping.c call-command-handler.c callback-stub.c cli.c stack-handler-stub.c
    $--frameworkDirFromProjFs--$/cli/: core-cli.c network-cli.c option-cli.c plugin-cli.c security-cli.c zcl-cli.c zdo-cli.c
    $--frameworkDirFromProjFs--$/security/: af-node.c af-security-common.c af-trust-center.c crypto-state.c
    $--frameworkDirFromProjFs--$/util/: af-event.c af-main-common.c af-main-host.c attribute-size.c attribute-storage.c attribute-table.c client-api.c message.c multi-network.c print-formatter.c print.c process-cluster-message.c process-global-message.c service-discovery-common.c service-discovery-host.c time-util.c util.c
    $--frameworkDirFromProjFs--$/../util/common/: library.c
    $--frameworkDirFromProjFs--$/../util/gateway/: gateway-stub.c
    $--frameworkDirFromProjFs--$/../util/serial/: command-interpreter2.c
    $--halDirFromProjFs--$/plugin/serial/: serial.c
    $--frameworkDirFromProjFs--$/../util/zigbee-framework/: zigbee-device-common.c zigbee-device-host.c
    $--frameworkDirFromProjFs--$/../../stack/framework/: event-control.c
    $--halDirFromProjFs--$/host/cortexm3/stm32f103ret/: button.c led.c micro.c spi-protocol.c system-timer.c uart.c
    $--halDirFromProjFs--$/plugin/adc/: adc-stm32f103ret.c
    $--halDirFromProjFs--$/plugin/buzzer/: buzzer-stm32f103ret.c
    $--halDirFromProjFs--$/host/cortexm3/stm32f103ret/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    $--halDirFromProjFs--$/host/cortexm3/stm32f103ret/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
    $--halDirFromProjFs--$/host/cortexm3/stm32f103ret/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    $--halDirFromProjFs--$/host/cortexm3/stm32f103ret/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    $--halDirFromProjFs--$/host/generic/: crc.c
