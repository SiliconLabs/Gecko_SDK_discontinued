# Keil uVision project userpage.uvprojx, settings and files
target userpage (ARM-ADS)
  device: EFM32G890F128 Silicon Labs
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(14000000) CPUTYPE("Cortex-M3")
  output: userpage
  AfterMake: fromelf.exe --bin --output obj\userpage.bin obj\userpage.axf
  c flags: Optim=4 oTime=1
  c define: EFM32G890F128
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32G\Include;..\..\..\..\..\emlib\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config;..\..\..\..\..\emdrv\common\inc;..\..\..\..\..\emdrv\rtcdrv\inc;..
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ram_code.sct
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32G/Source/ARM/: startup_efm32g.s
    ../../../../../Device/SiliconLabs/EFM32G/Source/: system_efm32g.c
  group BSP
    ../../../../common/bsp/: bsp_trace.c
  group Drivers
    ../../../../common/drivers/: segmentlcd.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_rtc.c em_system.c em_msc.c em_lcd.c em_int.c
  group emdrv
    ../../../../../emdrv/rtcdrv/src/: rtcdriver.c
  group Source
    ../: userpage.c
