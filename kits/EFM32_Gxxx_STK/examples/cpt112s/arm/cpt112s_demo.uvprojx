# Keil uVision project cpt112s_demo.uvprojx, settings and files
target cpt112s_demo (ARM-ADS)
  device: EFM32G890F128 Silicon Labs
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(14000000) CPUTYPE("Cortex-M3")
  output: cpt112s_demo
  AfterMake: fromelf.exe --bin --output obj\cpt112s_demo.bin obj\cpt112s_demo.axf
  c flags: Optim=4 oTime=1
  c define: EFM32G890F128 DEBUG_EFM
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32G\Include;..\..\..\..\..\emlib\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config;..\..\..\..\..\reptile\glib;..\..\..\..\..\reptile\glib\dmd;..\..\..\..\..\reptile\glib\dmd\ssd2119;..\..\..\..\..\reptile\glib\glib
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32G/Source/ARM/: startup_efm32g.s
    ../../../../../Device/SiliconLabs/EFM32G/Source/: system_efm32g.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_i2c.c em_lcd.c em_system.c
  group Drivers
    ../../../../common/drivers/: cpt112s_i2c.c retargetio.c retargetswo.c segmentlcd.c
  group Source
    ../: cpt112s_demo.c
