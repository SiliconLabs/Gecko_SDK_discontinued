# Keil uVision project rtx_tickless.uvprojx, settings and files
target rtx_tickless (ARM-ADS)
  device: EFM32G890F128 Silicon Labs
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(14000000) CPUTYPE("Cortex-M3")
  output: rtx_tickless
  AfterMake: fromelf.exe --bin --output obj\rtx_tickless.bin obj\rtx_tickless.axf
  c flags: Optim=4 oTime=1
  c define: EFM32G890F128
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32G\Include;..\..\..\..\..\emlib\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\..\..\reptile\RTX\Inc;..\..\..\config
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32G/Source/ARM/: startup_efm32g.s
    ../../../../../Device/SiliconLabs/EFM32G/Source/: system_efm32g.c
  group Drivers
    ../../../../common/drivers/: segmentlcd.c
  group BSP
    ../../../../common/bsp/: bsp_trace.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_lcd.c em_rtc.c em_system.c
  group Source
    ../: rtx_tickless.c RTX_Conf_CM.c
  group Libraries
    ../../../../../reptile/RTX/LIB/ARM/: RTX_CM3.lib
