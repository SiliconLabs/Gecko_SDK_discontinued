# Keil uVision project energy.uvprojx, settings and files
target energy (ARM-ADS)
  device: EFM32G890F128 Silicon Labs
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(14000000) CPUTYPE("Cortex-M3")
  output: energy
  AfterMake: fromelf.exe --bin --output obj\energy.bin obj\energy.axf
  c flags: Optim=4 oTime=1
  c define: EFM32G890F128
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32G\Include;..\..\..\..\..\emlib\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32G/Source/ARM/: startup_efm32g.s
    ../../../../../Device/SiliconLabs/EFM32G/Source/: system_efm32g.c
  group BSP
    ../../../../common/bsp/: bsp_bcc.c bsp_stk.c bsp_trace.c
  group Drivers
    ../../../../common/drivers/: vddcheck.c segmentlcd.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_rtc.c em_lcd.c em_system.c em_usart.c em_vcmp.c
  group Source
    ../: energy.c
