# IAR project cslib.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32GG990F1024 SiliconLaboratories EFM32GG990F1024
  ICCARM.CCDefines: EFM32GG990F1024; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\SiliconLabs\EFM32GG\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\common\bsp; ..\..\..\config; ..\..\..\..\..\reptile\cslib\inc; ..\..\..\..\..\reptile\cslib\src\app; ..\..\..\..\..\reptile\cslib\src\device_LESENSE; ..\..\..\..\..\reptile\cslib\src\serial; ..\..\..\..\..\reptile\cslib\src\config_LESENSE; ..\..\..\..\..\emdrv\rtcdrv\inc; ..\..\..\..\..\emdrv\common\inc; ..\..\..\..\common\drivers
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cslib.bin
  ILINK.IlinkOutputFile: cslib.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\reptile\cslib\lib\libCSLIB_M3_4_iar.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32GG990F1024; DEBUG_EFM
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32GG/Source/IAR/: startup_efm32gg.s
    ../../../../../Device/SiliconLabs/EFM32GG/Source/: system_efm32gg.c
  group bsp
    ../../../../common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
  group drivers
    ../../../../../emdrv/rtcdrv/src/: rtcdriver.c
  group emlib
    ../../../../../emlib/src/: em_acmp.c em_assert.c em_cmu.c em_ebi.c em_emu.c em_gpio.c em_int.c em_lesense.c em_rtc.c em_system.c em_vcmp.c em_leuart.c em_usart.c
  group app
    ../../../../../reptile/cslib/src/app/: cslib_config.c device_init.c main.c
  group device_LESENSE
    ../../../../../reptile/cslib/src/device_LESENSE/: hardware_config.c hardware_routines.c low_power_config.c
  group serial
    ../../../../../reptile/cslib/src/serial/: comm_routines.c profiler_interface.c retargetvirtual.c sensor_descriptors.c
    ../../../../common/drivers/: retargetio.c
