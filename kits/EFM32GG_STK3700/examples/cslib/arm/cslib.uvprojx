# Keil uVision project cslib.uvprojx, settings and files
target cslib (ARM-ADS)
  device: EFM32GG990F1024 Silicon Labs
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0xFFFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: cslib
  AfterMake: fromelf.exe --bin --output obj\cslib.bin obj\cslib.axf
  c flags: Optim=1
  c define: EFM32GG990F1024 DEBUG_EFM
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32GG\Include;..\..\..\..\..\emlib\inc;..\..\..\..\common\bsp;..\..\..\config;..\..\..\..\..\reptile\cslib\inc;..\..\..\..\..\reptile\cslib\src\app;..\..\..\..\..\reptile\cslib\src\device_LESENSE;..\..\..\..\..\reptile\cslib\src\serial;..\..\..\..\..\reptile\cslib\src\config_LESENSE;..\..\..\..\..\emdrv\rtcdrv\inc;..\..\..\..\..\emdrv\common\inc;..\..\..\..\common\drivers
  asm define: EFM32GG990F1024 DEBUG_EFM
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32GG/Source/ARM/: startup_efm32gg.s
    ../../../../../Device/SiliconLabs/EFM32GG/Source/: system_efm32gg.c
  group bsp
    ../../../../common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
  group drivers
    ../../../../../emdrv/rtcdrv/src/: rtcdriver.c
  group emlib
    ../../../../../emlib/src/: em_acmp.c em_assert.c em_cmu.c em_ebi.c em_emu.c em_gpio.c em_int.c em_lesense.c em_rtc.c em_system.c em_vcmp.c em_leuart.c em_usart.c
  group app
    ../../../../../reptile/cslib/src/app/: cslib_config.c device_init.c main.c
  group device_LESENSE
    ../../../../../reptile/cslib/src/device_LESENSE/: hardware_config.c hardware_routines.c low_power_config.c
  group serial
    ../../../../../reptile/cslib/src/serial/: comm_routines.c profiler_interface.c retargetvirtual.c sensor_descriptors.c
    ../../../../common/drivers/: retargetio.c
  group Libraries
    ../../../../../reptile/cslib/lib/: libCSLIB_M3_4_arm.lib
