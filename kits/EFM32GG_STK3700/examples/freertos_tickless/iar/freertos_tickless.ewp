# IAR project freertos_tickless.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32GG990F1024 SiliconLaboratories EFM32GG990F1024
  ICCARM.CCDefines: EFM32GG990F1024; IAR_ARM_CM3; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\SiliconLabs\EFM32GG\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\..\emdrv\sleep\inc; ..\..\..\..\common\drivers; ..\..\..\..\common\bsp; ..; ..\..\..\..\..\reptile\FreeRTOS\Source\include; ..\..\..\..\..\reptile\FreeRTOS\Source\portable\IAR\ARM_CM3; ..\..\..\config
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_tickless.bin
  ILINK.IlinkOutputFile: freertos_tickless.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32GG990F1024; IAR_ARM_CM3; DEBUG_EFM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32GG/Source/IAR/: startup_efm32gg.s
    ../../../../../Device/SiliconLabs/EFM32GG/Source/: system_efm32gg.c
  group Drivers
    ../../../../common/drivers/: segmentlcd.c
  group BSP
    ../../../../common/bsp/: bsp_trace.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_burtc.c em_cmu.c em_emu.c em_gpio.c em_int.c em_lcd.c em_rmu.c em_rtc.c em_system.c
  group emdrv
    ../../../../../emdrv/sleep/src/: sleep.c
  group FreeRTOS
    ../../../../../reptile/FreeRTOS/Source/: timers.c tasks.c queue.c list.c croutine.c event_groups.c
    ../../../../../reptile/FreeRTOS/Source/portable/MemMang/: heap_1.c
    ../../../../../reptile/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group Source
    ../: main.c low_power_tick_management.c
