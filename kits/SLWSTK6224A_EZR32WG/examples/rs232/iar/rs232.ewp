# IAR project rs232.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EZR32WG330F256R63 SiliconLaboratories EZR32WG330F256R63
  ICCARM.CCDefines: EZR32WG330F256R63; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\SiliconLabs\EZR32WG\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\common\bsp; ..\..\..\..\common\drivers; ..\..\..\config
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: rs232.bin
  ILINK.IlinkOutputFile: rs232.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EZR32WG330F256R63; DEBUG_EFM
  group Drivers
    ../../../../common/drivers/: retargetio.c retargetserial.c
  group CMSIS
    ../../../../../Device/SiliconLabs/EZR32WG/Source/IAR/: startup_ezr32wg.s
    ../../../../../Device/SiliconLabs/EZR32WG/Source/: system_ezr32wg.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_system.c em_cmu.c em_emu.c em_gpio.c em_ebi.c em_int.c em_usart.c em_leuart.c
  group Source
    ../: main.c
