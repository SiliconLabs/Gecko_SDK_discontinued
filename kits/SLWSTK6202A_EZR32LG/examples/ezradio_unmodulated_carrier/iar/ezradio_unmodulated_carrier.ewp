# IAR project ezradio_unmodulated_carrier.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EZR32LG330F256R63 SiliconLaboratories EZR32LG330F256R63
  ICCARM.CCDefines: EZR32LG330F256R63; SL_WSTK6202A; EZRADIO_DRIVER_EXTENDED_SUPPORT; EZRADIO_DRIVER_FULL_SUPPORT
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\SiliconLabs\EZR32LG\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\..\kits\common\drivers; ..\..\..\..\..\reptile\glib; ..\..\..\..\..\kits\common\bsp; ..\..\..\config; ..\..\..\..\..\emdrv\common\inc; ..\..\..\..\..\emdrv\dmadrv\inc; ..\..\..\..\..\emdrv\gpiointerrupt\inc; ..\..\..\..\..\emdrv\rtcdrv\inc; ..\..\..\..\..\emdrv\spidrv\inc; ..\..\..\..\..\emdrv\ustimer\inc; ..\..\..\..\..\emdrv\ezradiodrv\common\inc; ..\..\..\..\..\emdrv\ezradiodrv\common\inc\si4x6x; ..\..\..\..\..\emdrv\ezradiodrv\si4463\inc; ..\..\..\..\..\emdrv\ezradiodrv\plugins\inc; ..; ..\config; ..\config\RadioConfig
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ezradio_unmodulated_carrier.bin
  ILINK.IlinkOutputFile: ezradio_unmodulated_carrier.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EZR32LG330F256R63; SL_WSTK6202A; EZRADIO_DRIVER_EXTENDED_SUPPORT; EZRADIO_DRIVER_FULL_SUPPORT
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../Device/SiliconLabs/EZR32LG/Source/IAR/: startup_ezr32lg.s
    ../../../../../Device/SiliconLabs/EZR32LG/Source/: system_ezr32lg.c
  group Drivers
    ../../../../../kits/common/drivers/: display.c displayls013b7dh03.c displaypalemlib.c dmactrl.c retargetio.c retargettextdisplay.c textdisplay.c udelay.c
  group dmadrv
    ../../../../../emdrv/dmadrv/src/: dmadrv.c
  group ezradiodrv
    ../../../../../emdrv/ezradiodrv/common/src/: ezradio_api_lib.c ezradio_comm.c ezradio_hal.c
    ../../../../../emdrv/ezradiodrv/common/src/si4x6x/: ezradio_api_lib_add.c
    ../../../../../emdrv/ezradiodrv/plugins/src/: ezradio_plugin_manager.c ezradio_transmit_plugin.c ezradio_receive_plugin.c ezradio_crcerror_plugin.c ezradio_auto_ack_plugin.c ezradio_unmod_carrier_plugin.c ezradio_pn9_plugin.c ezradio_direct_transmit_plugin.c ezradio_direct_receive_plugin.c
  group gpiointerrupt
    ../../../../../emdrv/gpiointerrupt/src/: gpiointerrupt.c
  group rtcdrv
    ../../../../../emdrv/rtcdrv/src/: rtcdriver.c
  group spidrv
    ../../../../../emdrv/spidrv/src/: spidrv.c
  group ustimer
    ../../../../../emdrv/ustimer/src/: ustimer.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_emu.c em_dma.c em_gpio.c em_int.c em_pcnt.c em_prs.c em_rtc.c em_system.c em_timer.c em_usart.c
  group Source
    ../: main.c
