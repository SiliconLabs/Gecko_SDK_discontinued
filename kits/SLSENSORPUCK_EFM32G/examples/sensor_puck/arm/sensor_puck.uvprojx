# Keil uVision project sensor_puck.uvprojx, settings and files
target sensor_puck (ARM-ADS)
  device: EFM32G210F128 Silicon Labs
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(14000000) CPUTYPE("Cortex-M3")
  output: sensor_puck
  AfterMake: fromelf.exe --bin --output obj\sensor_puck.bin obj\sensor_puck.axf
  c flags: Optim=4 oTime=1
  c define: EFM32G210F128 EFM32_HFXO_FREQ=24000000UL
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32G\Include;..\..\..\..\..\emlib\inc;..\..\..\..\..\kits\common\drivers;..\..\..;..\..\..\config;..\..\..\..\..\emdrv\rtcdrv\inc;..\..\..\..\..\emdrv\common\inc;..\..\..\..\..\emdrv\config;..\..\..\..\..\reptile\si114xhrm\inc;..\..\..\..\..\kits\common\drivers
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ram_code.sct
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32G/Source/ARM/: startup_efm32g.s
    ../../../../../Device/SiliconLabs/EFM32G/Source/: system_efm32g.c
  group Drivers
    ../../../../../kits/common/drivers/: si7013.c si114x_functions.c
    ../: i2cspm_int.c
  group emlib
    ../../../../../emlib/src/: em_adc.c em_assert.c em_cmu.c em_dma.c em_emu.c em_gpio.c em_lcd.c em_prs.c em_system.c em_timer.c em_usart.c em_int.c em_rtc.c em_i2c.c em_msc.c em_leuart.c
  group Source
    ../: sensor_puck.c heart_rate_monitor.c ble.c ble_uart.c si114x_environmental.c rtcdriver_lfrco.c trace.c si114x_sys_out_puck.c
  group Libraries
    ../../../../../reptile/si114xhrm/lib/: si114xHRM_ARM_CM3.lib
