# IAR project sensor_puck.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32G210F128 SiliconLaboratories EFM32G210F128
  ICCARM.CCDefines: EFM32G210F128; EFM32_HFXO_FREQ=24000000UL; RTCDRV_USE_LFRCO
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\SiliconLabs\EFM32G\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\..\kits\common\drivers; ..\..\..; ..\..\..\config; ..\..\..\..\..\emdrv\rtcdrv\inc; ..\..\..\..\..\emdrv\common\inc; ..\..\..\..\..\emdrv\config; ..\..\..\..\..\reptile\si114xhrm\inc; ..\..\..\..\..\kits\common\drivers
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sensor_puck.bin
  ILINK.IlinkOutputFile: sensor_puck.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\reptile\si114xhrm\lib\libsi114xHRM_IAR_CM3.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32G210F128; EFM32_HFXO_FREQ=24000000UL; RTCDRV_USE_LFRCO
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32G/Source/IAR/: startup_efm32g.s
    ../../../../../Device/SiliconLabs/EFM32G/Source/: system_efm32g.c
  group Drivers
    ../../../../../kits/common/drivers/: si7013.c si114x_functions.c
  group emlib
    ../../../../../emlib/src/: em_adc.c em_assert.c em_cmu.c em_dma.c em_emu.c em_gpio.c em_lcd.c em_prs.c em_system.c em_timer.c em_usart.c em_int.c em_rtc.c em_i2c.c em_msc.c em_leuart.c
  group emdrv
    ../../../../../emdrv/rtcdrv/src/: rtcdriver.c
  group Source
    ../: sensor_puck.c heart_rate_monitor.c ble.c ble_uart.c si114x_environmental.c trace.c si114x_sys_out_puck.c i2cspm_int.c
