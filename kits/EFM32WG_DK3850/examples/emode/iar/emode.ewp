# IAR project emode.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32WG990F256 SiliconLaboratories EFM32WG990F256
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32WG990F256; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\SiliconLabs\EFM32WG\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\common\drivers; ..\..\..\..\common\bsp; ..\..\..\config; ..; ..\..\..\..\..\reptile\glib; ..\..\..\..\..\emdrv\common\inc; ..\..\..\..\..\emdrv\rtcdrv\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: emode.bin
  ILINK.IlinkOutputFile: emode.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32WG990F256; DEBUG_EFM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32WG/Source/IAR/: startup_efm32wg.s
    ../../../../../Device/SiliconLabs/EFM32WG/Source/: system_efm32wg.c
  group BSP
    ../../../../common/bsp/: bsp_dk_3201.c bsp_dk_leds.c bsp_trace.c
  group Drivers
    ../../../../common/drivers/: tftamapped.c
  group glib
    ../../../../../reptile/glib/dmd/ssd2119/: dmd_ssd2119_16bit.c dmdif_ssd2119_ebi16.c
    ../../../../../reptile/glib/glib/: glib.c glib_bitmap.c glib_circle.c glib_line.c glib_polygon.c glib_rectangle.c glib_string.c glib_font_normal_8x8.c glib_font_narrow_6x8.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_system.c em_cmu.c em_emu.c em_ebi.c em_gpio.c em_usart.c em_rtc.c em_int.c
  group emdrv
    ../../../../../emdrv/rtcdrv/src/: rtcdriver.c
  group Source
    ../: emode.c
