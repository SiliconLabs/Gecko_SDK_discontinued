# IAR project webserver.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32WG990F256 SiliconLaboratories EFM32WG990F256
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32WG990F256; DEBUG_EFM; __HEAP_SIZE=128
  ICCARM.CCDiagSuppress: Pa050,Pe550
  ICCARM.CCIncludePath2: ..; ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\SiliconLabs\EFM32WG\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\..\emdrv\spidrv\inc; ..\..\..\..\..\emdrv\common\inc; ..\..\..\..\..\emdrv\config; ..\..\..\..\..\emdrv\rtcdrv\inc; ..\..\..\..\..\emdrv\dmadrv\inc; ..\..\..\..\common\drivers; ..\..\..\..\common\bsp; ..\..\..\config; ..\..\..\..\..\reptile\glib; ..\..\..\..\..\reptile\glib\glib; ..\..\..\..\..\reptile\lwIP\lwip\src\; ..\..\..\..\..\reptile\lwIP\lwip\src\api; ..\..\..\..\..\reptile\lwIP\lwip\src\core; ..\..\..\..\..\reptile\lwIP\lwip\src\core\ipv4; ..\..\..\..\..\reptile\lwIP\lwip\src\include; ..\..\..\..\..\reptile\lwIP\lwip\src\include\ipv4; ..\..\..\..\..\reptile\lwIP\lwip\src\include\ipv4\lwip; ..\..\..\..\..\reptile\lwIP\lwip\src\include\lwip; ..\..\..\..\..\reptile\lwIP\lwip-contrib\apps\ping; ..\..\..\..\..\reptile\lwIP\lwip-contrib\apps\tcpecho_raw; ..\..\..\..\..\reptile\lwIP\lwip-contrib\apps\httpserver_raw; ..\..\..\..\..\reptile\lwIP\lwip-contrib\ports\EFM32\; ..\..\..\..\..\reptile\lwIP\lwip-contrib\ports\EFM32\include\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: webserver.bin
  ILINK.IlinkOutputFile: webserver.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32WG990F256; DEBUG_EFM; __HEAP_SIZE=128
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32WG/Source/IAR/: startup_efm32wg.s
    ../../../../../Device/SiliconLabs/EFM32WG/Source/: system_efm32wg.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_system.c em_cmu.c em_emu.c em_gpio.c em_ebi.c em_usart.c em_rtc.c em_dma.c em_int.c
  group emdrv
    ../../../../../emdrv/spidrv/src/: spidrv.c
    ../../../../../emdrv/rtcdrv/src/: rtcdriver.c
    ../../../../../emdrv/dmadrv/src/: dmadrv.c
  group BSP
    ../../../../common/bsp/: bsp_dk_3201.c bsp_trace.c bsp_dk_leds.c
  group Drivers
    ../../../../common/drivers/: ksz8851snl.c ksz8851snl_spi.c retargetserial.c retargetio.c dmactrl.c
    ../: tftconsole.c
  group Graphics
    ../../../../../reptile/glib/dmd/ssd2119/: dmd_ssd2119_16bit.c dmdif_ssd2119_ebi16.c
  group lwip
    ../../../../../reptile/lwIP/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../reptile/lwIP/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../../reptile/lwIP/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../../../reptile/lwIP/lwip/src/netif/: etharp.c ethernetif.c
  group lwip-contrib
    ../../../../../reptile/lwIP/lwip-contrib/apps/tcpecho_raw/: echo.c
    ../../../../../reptile/lwIP/lwip-contrib/apps/httpserver_raw/: fs.c httpd.c
    ../../../../../reptile/lwIP/lwip-contrib/ports/efm32/: ksz8851snl_driver.c
  group Source
    ../: webserver.c
