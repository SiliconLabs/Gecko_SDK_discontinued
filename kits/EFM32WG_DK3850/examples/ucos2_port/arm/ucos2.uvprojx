# Keil uVision project ucos2.uvprojx, settings and files
target ucos2 (ARM-ADS)
  device: EFM32WG990F256 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(48000000) CPUTYPE("Cortex-M4") FPU2
  output: ucos2
  AfterMake: fromelf.exe --bin --output obj\ucos2.bin obj\ucos2.axf
  c flags: Optim=4 oTime=1
  c define: EFM32WG990F256
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32WG\Include;..\..\..\..\..\emlib\inc;..\src\bsp;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config;..\src\app;..\..\..\..\..\reptile\glib;..\..\..\..\..\reptile\Micrium\uCOS-II\uc-cpu;..\..\..\..\..\reptile\Micrium\uCOS-II\uc-lib;..\..\..\..\..\reptile\Micrium\uCOS-II\ucos-ii\Source;..\..\..\..\..\reptile\Micrium\uCOS-II\uc-cpu\ARM-Cortex-M4\RealView;..\..\..\..\..\reptile\Micrium\uCOS-II\ucos-ii\Ports\ARM-Cortex-M4\Generic\RealView
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ../src/app/: app.c app_hooks.c app_task_one.c app_task_two.c app_task_three.c
  group BSP-DVK
    ../src/bsp/: bsp-uart.c
    ../../../../common/bsp/: bsp_dk_3201.c bsp_dk_leds.c bsp_trace.c
  group Drivers
    ../../../../common/drivers/: retargettft.c retargetio.c
  group Graphics
    ../../../../../reptile/glib/dmd/ssd2119/: dmd_ssd2119_16bit.c dmdif_ssd2119_ebi16.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_int.c em_emu.c em_ebi.c em_gpio.c em_system.c em_usart.c
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32WG/Source/: system_efm32wg.c
    ../../../../../reptile/Micrium/uCOS-II/startup/EFM32WG/arm/: startup_efm32wg.s
  group uC/CPU
    ../../../../../reptile/Micrium/uCOS-II/uc-cpu/: cpu_core.c
    ../../../../../reptile/Micrium/uCOS-II/uc-cpu/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
  group uC/LIB
    ../../../../../reptile/Micrium/uCOS-II/uc-lib/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uC/OS-II
    ../../../../../reptile/Micrium/uCOS-II/ucos-ii/Source/: ucos_ii.c
    ../../../../../reptile/Micrium/uCOS-II/ucos-ii/Ports/ARM-Cortex-M4/Generic/RealView/: os_dbg.c os_cpu_c.c os_cpu_a.asm
