# Keil uVision project rs232.uvprojx, settings and files
target rs232 (ARM-ADS)
  device: EFM32WG990F256 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(48000000) CPUTYPE("Cortex-M4") FPU2
  output: rs232
  AfterMake: fromelf.exe --bin --output obj\rs232.bin obj\rs232.axf
  c flags: Optim=1
  c define: EFM32WG990F256 DEBUG_EFM
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32WG\Include;..\..\..\..\..\emlib\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config
  asm define: EFM32WG990F256 DEBUG_EFM
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group bsp
    ../../../../common/bsp/: bsp_dk_3201.c bsp_trace.c
  group Drivers
    ../../../../common/drivers/: retargetio.c retargetserial.c
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32WG/Source/ARM/: startup_efm32wg.s
    ../../../../../Device/SiliconLabs/EFM32WG/Source/: system_efm32wg.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_system.c em_cmu.c em_emu.c em_gpio.c em_ebi.c em_int.c em_usart.c em_leuart.c
  group Source
    ../: main.c
