# Keil uVision project ucos3.uvprojx, settings and files
target ucos3 (ARM-ADS)
  device: EFM32WG990F256 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(48000000) CPUTYPE("Cortex-M4") FPU2
  output: ucos3
  AfterMake: fromelf.exe --bin --output obj\ucos3.bin obj\ucos3.axf
  c flags: Optim=4
  c define: EFM32WG990F256
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32WG\Include;..\..\..\..\..\emlib\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config;..\src\bsp;..\src\app;..\..\..\..\..\reptile\glib;..\..\..\..\..\reptile\Micrium\uCOS-III\uc-cpu;..\..\..\..\..\reptile\Micrium\uCOS-III\uc-lib;..\..\..\..\..\reptile\Micrium\uCOS-III\ucos-iii\Source;..\..\..\..\..\reptile\Micrium\uCOS-III\uc-cpu\ARM-Cortex-M4\RealView;..\..\..\..\..\reptile\Micrium\uCOS-III\ucos-iii\Ports\ARM-Cortex-M4\Generic\RealView
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ../src/app/: app.c app_hooks.c app_task_one.c app_task_two.c app_task_three.c
  group BSP-DVK
    ../src/bsp/: bsp-uart.c
    ../../../../common/bsp/: bsp_dk_3201.c bsp_dk_leds.c bsp_trace.c
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32WG/Source/: system_efm32wg.c
    ../../../../../reptile/Micrium/uCOS-III/startup/EFM32WG/arm/: startup_efm32wg.s
  group Drivers
    ../../../../common/drivers/: retargetio.c retargettft.c
  group Graphics
    ../../../../../reptile/glib/dmd/ssd2119/: dmd_ssd2119_16bit.c dmdif_ssd2119_ebi16.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_emu.c em_ebi.c em_gpio.c em_system.c em_usart.c em_leuart.c em_int.c
  group uC/CPU
    ../../../../../reptile/Micrium/uCOS-III/uc-cpu/: cpu_core.c
    ../../../../../reptile/Micrium/uCOS-III/uc-cpu/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
  group uC/OS-III
    ../../../../../reptile/Micrium/uCOS-III/ucos-iii/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../../../../../reptile/Micrium/uCOS-III/ucos-iii/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_c.c os_cpu_a.asm
