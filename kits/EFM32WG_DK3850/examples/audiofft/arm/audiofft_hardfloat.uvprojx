# Keil uVision project audiofft_hardfloat.uvprojx, settings and files
target audiofft_hardfloat (ARM-ADS)
  device: EFM32WG990F256 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(48000000) CPUTYPE("Cortex-M4") FPU2
  output: audiofft_hardfloat
  AfterMake: fromelf.exe --bin --output obj\audiofft_hardfloat.bin obj\audiofft_hardfloat.axf
  c flags: Optim=4 oTime=1
  c define: EFM32WG990F256 __FPU_PRESENT=1 ARM_MATH_CM4
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32WG\Include;..\..\..\..\..\emlib\inc;..\..\..\..\..\emdrv\common\inc;..\..\..\..\..\emdrv\config;..\..\..\..\..\emdrv\rtcdrv\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\..\..\reptile\glib;..\..\..\..\..\reptile\emwin\inc;..\..\..\..\common\drivers\emwin\Dk3750;..\..\..\config
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group BSP
    ../../../../common/bsp/: bsp_dk_3201.c bsp_dk_leds.c bsp_trace.c
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32WG/Source/ARM/: startup_efm32wg.s
    ../../../../../Device/SiliconLabs/EFM32WG/Source/: system_efm32wg.c
  group Drivers
    ../../../../common/drivers/: dmactrl.c tftdirect.c tftspi.c
    ../../../../../reptile/glib/dmd/ssd2119/: dmd_ssd2119_direct.c
  group emdrv
    ../../../../../emdrv/rtcdrv/src/: rtcdriver.c
  group DSP
    ../../../../../CMSIS/DSP_Lib/Source/TransformFunctions/: arm_bitreversal.c arm_cfft_radix4_f32.c arm_cfft_radix4_init_f32.c arm_rfft_f32.c arm_rfft_init_f32.c
    ../../../../../CMSIS/DSP_Lib/Source/ComplexMathFunctions/: arm_cmplx_mag_f32.c
    ../../../../../CMSIS/DSP_Lib/Source/CommonTables/: arm_common_tables.c
  group emlib
    ../../../../../emlib/src/: em_adc.c em_assert.c em_cmu.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_int.c em_prs.c em_rtc.c em_system.c em_timer.c em_usart.c
  group Source
    ../: audiofft.c plot.c logo.c GUIConf.c GUI_X.c LCDConf.c GUIResource.c
  group Libraries
    ../../../../../reptile/emwin/lib/: emwin_ARM_CM4F.lib
