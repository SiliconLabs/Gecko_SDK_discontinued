# IAR project clock.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EZR32HG320F64R68 SiliconLaboratories EZR32HG320F64R68
  ICCARM.CCDefines: EZR32HG320F64R68; GLIB_NO_DEFAULT_FONT
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\SiliconLabs\EZR32HG\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\..\kits\common\drivers; ..\..\..\..\..\reptile\glib; ..\..\..\..\..\reptile\glib\glib; ..\..\..\..\..\reptile\glib\dmd; ..\..\..\..\..\kits\common\bsp; ..\..\..\config; ..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: clock.bin
  ILINK.IlinkOutputFile: clock.out
  ILINK.IlinkIcfFile: ..\clock.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EZR32HG320F64R68; GLIB_NO_DEFAULT_FONT
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../Device/SiliconLabs/EZR32HG/Source/IAR/: startup_ezr32hg.s
    ../../../../../Device/SiliconLabs/EZR32HG/Source/: system_ezr32hg.c
  group Drivers
    ../../../../../kits/common/drivers/: display.c displayls013b7dh03.c displaypalemlib.c retargetio.c retargettextdisplay.c textdisplay.c udelay.c
  group glib
    ../../../../../reptile/glib/dmd/display/: dmd_display.c
    ../../../../../reptile/glib/glib/: glib.c glib_bitmap.c glib_circle.c glib_line.c glib_rectangle.c glib_string.c glib_font_narrow_6x8.c glib_font_number_16x20.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_int.c em_pcnt.c em_prs.c em_rtc.c em_system.c em_usart.c
  group Source
    ../: main.c analog_clock.c
