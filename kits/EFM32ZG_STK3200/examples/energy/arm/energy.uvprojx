# Keil uVision project energy.uvprojx, settings and files
target energy (ARM-ADS)
  device: EFM32ZG222F32 Silicon Labs
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(24000000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: energy
  AfterMake: fromelf.exe --bin --output obj\energy.bin obj\energy.axf
  c flags: Optim=1 oTime=1
  c define: EFM32ZG222F32 DEBUG_EFM
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32ZG\Include;..\..\..\..\..\emlib\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config;..;..\..\..\..\..\reptile\glib
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32ZG/Source/ARM/: startup_efm32zg.s
    ../../../../../Device/SiliconLabs/EFM32ZG/Source/: system_efm32zg.c
  group Drivers
    ../../../../common/drivers/: udelay.c retargetio.c retargettextdisplay.c textdisplay.c display.c displaypalemlib.c displayls013b7dh03.c
  group BSP
    ../../../../common/bsp/: bsp_bcc.c bsp_stk.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_int.c em_leuart.c em_prs.c em_rtc.c em_timer.c em_usart.c
  group Source
    ../: main.c
