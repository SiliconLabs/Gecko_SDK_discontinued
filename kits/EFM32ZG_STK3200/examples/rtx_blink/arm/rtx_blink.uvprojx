# Keil uVision project rtx_blink.uvprojx, settings and files
target rtx_blink (ARM-ADS)
  device: EFM32ZG222F32 Silicon Labs
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(24000000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: rtx_blink
  AfterMake: fromelf.exe --bin --output obj\rtx_blink.bin obj\rtx_blink.axf
  c flags: Optim=4 oTime=1
  c define: EFM32ZG222F32
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32ZG\Include;..\..\..\..\..\emlib\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\..\..\reptile\RTX\Inc;..\..\..\config
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32ZG/Source/ARM/: startup_efm32zg.s
    ../../../../../Device/SiliconLabs/EFM32ZG/Source/: system_efm32zg.c
  group BSP
    ../../../../common/bsp/: bsp_stk_leds.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_lcd.c em_system.c
  group Source
    ../: rtx_blink.c RTX_Conf_CM.c
  group Libraries
    ../../../../../reptile/RTX/LIB/ARM/: RTX_CM0.lib
