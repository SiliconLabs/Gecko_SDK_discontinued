# IAR project freertos_tickless.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32ZG222F32 SiliconLaboratories EFM32ZG222F32
  ICCARM.CCDefines: EFM32ZG222F32; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\SiliconLabs\EFM32ZG\Include; ..\..\..\..\common\drivers; ..\..\..\..\common\bsp; ..\..\..\..\..\emlib\inc; ..\..\..\..\..\emdrv\sleep\inc; ..\..\..\..\..\reptile\glib; ..\..\..\config; ..; ..\..\..\..\..\reptile\FreeRTOS\Source\include; ..\..\..\..\..\reptile\FreeRTOS\Source\portable\IAR\ARM_CM0
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_tickless.bin
  ILINK.IlinkOutputFile: freertos_tickless.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32ZG222F32; DEBUG_EFM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32ZG/Source/IAR/: startup_efm32zg.s
    ../../../../../Device/SiliconLabs/EFM32ZG/Source/: system_efm32zg.c
  group Drivers
    ../../../../common/drivers/: display.c displayls013b7dh03.c displaypalemlib.c udelay.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_int.c em_rtc.c em_system.c em_rmu.c em_usart.c em_timer.c
  group emdrv
    ../../../../../emdrv/sleep/src/: sleep.c
  group FreeRTOS
    ../../../../../reptile/FreeRTOS/Source/: timers.c tasks.c queue.c list.c croutine.c event_groups.c
    ../../../../../reptile/FreeRTOS/Source/portable/MemMang/: heap_1.c
    ../../../../../reptile/FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s
  group Source
    ../: main.c low_power_tick_management.c
