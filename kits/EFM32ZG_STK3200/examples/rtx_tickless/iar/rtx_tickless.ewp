# IAR project rtx_tickless.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32ZG222F32 SiliconLaboratories EFM32ZG222F32
  ICCARM.CCDefines: EFM32ZG222F32
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\SiliconLabs\EFM32ZG\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\common\drivers; ..\..\..\..\common\bsp; ..\..\..\..\..\reptile\RTX\Inc; ..\..\..\..\..\reptile\glib; ..\..\..\config; ..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: rtx_tickless.bin
  ILINK.IlinkOutputFile: rtx_tickless.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\reptile\RTX\LIB\IAR\RTX_CM0.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32ZG222F32
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32ZG/Source/IAR/: startup_efm32zg.s
    ../../../../../Device/SiliconLabs/EFM32ZG/Source/: system_efm32zg.c
  group Drivers
    ../../../../common/drivers/: display.c displayls013b7dh03.c displaypalemlib.c udelay.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_int.c em_lcd.c em_rtc.c em_system.c em_usart.c
  group Source
    ../: rtx_tickless.c RTX_Conf_CM.c
