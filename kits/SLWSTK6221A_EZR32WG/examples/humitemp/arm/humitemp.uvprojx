# Keil uVision project humitemp.uvprojx, settings and files
target humitemp (ARM-ADS)
  device: EZR32WG330F256R55 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(48000000) CPUTYPE("Cortex-M4") FPU2
  output: humitemp
  AfterMake: fromelf.exe --bin --output obj\humitemp.bin obj\humitemp.axf
  c flags: Optim=4
  c define: EZR32WG330F256R55
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EZR32WG\Include;..\..\..\..\..\emlib\inc;..\..\..\..\..\emdrv\common\inc;..\..\..\..\..\emdrv\rtcdrv\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config;..\..\..\..\..\reptile\glib;..\..\..\..\..\reptile\glib\glib;..\..\..\..\..\reptile\glib\dmd;..;..\..\..\..\..\emdrv\config
  asm define: EZR32WG330F256R55
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../../../Device/SiliconLabs/EZR32WG/Source/ARM/: startup_ezr32wg.s
    ../../../../../Device/SiliconLabs/EZR32WG/Source/: system_ezr32wg.c
  group bsp
    ../../../../common/bsp/: bsp_bcc.c bsp_stk.c
  group emdrv
    ../../../../../emdrv/rtcdrv/src/: rtcdriver.c
  group Drivers
    ../../../../common/drivers/: display.c displayls013b7dh03.c displaypalemlib.c udelay.c si7013.c i2cspm.c
  group glib
    ../../../../../reptile/glib/dmd/display/: dmd_display.c
    ../../../../../reptile/glib/glib/: glib.c glib_bitmap.c glib_circle.c glib_line.c glib_rectangle.c glib_string.c glib_font_normal_8x8.c glib_font_narrow_6x8.c
  group emlib
    ../../../../../emlib/src/: em_system.c em_adc.c em_assert.c em_cmu.c em_emu.c em_gpio.c em_int.c em_leuart.c em_rtc.c em_usart.c em_i2c.c
  group Source
    ../: humitemp.c graphics.c
