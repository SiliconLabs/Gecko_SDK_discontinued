# Keil uVision project ezradio_unmodulated_carrier.uvprojx, settings and files
target ezradio_unmodulated_carrier (ARM-ADS)
  device: EZR32WG330F256R55 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(48000000) CPUTYPE("Cortex-M4") FPU2
  output: ezradio_unmodulated_carrier
  AfterMake: fromelf.exe --bin --output obj\ezradio_unmodulated_carrier.bin obj\ezradio_unmodulated_carrier.axf
  c flags: Optim=4
  c define: EZR32WG330F256R55 SL_WSTK6221A EZRADIO_DRIVER_EXTENDED_SUPPORT EZRADIO_DRIVER_FULL_SUPPORT
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EZR32WG\Include;..\..\..\..\..\emlib\inc;..\..\..\..\..\kits\common\drivers;..\..\..\..\..\reptile\glib;..\..\..\..\..\kits\common\bsp;..\..\..\config;..\..\..\..\..\emdrv\common\inc;..\..\..\..\..\emdrv\dmadrv\inc;..\..\..\..\..\emdrv\gpiointerrupt\inc;..\..\..\..\..\emdrv\rtcdrv\inc;..\..\..\..\..\emdrv\spidrv\inc;..\..\..\..\..\emdrv\ustimer\inc;..\..\..\..\..\emdrv\ezradiodrv\common\inc;..\..\..\..\..\emdrv\ezradiodrv\common\inc\si4x55;..\..\..\..\..\emdrv\ezradiodrv\si4455\inc;..\..\..\..\..\emdrv\ezradiodrv\plugins\inc;..;..\config;..\config\RadioConfig
  asm define: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../../../Device/SiliconLabs/EZR32WG/Source/ARM/: startup_ezr32wg.s
    ../../../../../Device/SiliconLabs/EZR32WG/Source/: system_ezr32wg.c
  group Drivers
    ../../../../../kits/common/drivers/: display.c displayls013b7dh03.c displaypalemlib.c dmactrl.c retargetio.c retargettextdisplay.c textdisplay.c udelay.c
  group dmadrv
    ../../../../../emdrv/dmadrv/src/: dmadrv.c
  group ezradiodrv
    ../../../../../emdrv/ezradiodrv/common/src/: ezradio_api_lib.c ezradio_comm.c ezradio_hal.c
    ../../../../../emdrv/ezradiodrv/common/src/si4x55/: ezradio_api_lib_add.c
    ../../../../../emdrv/ezradiodrv/plugins/src/: ezradio_plugin_manager.c ezradio_transmit_plugin.c ezradio_receive_plugin.c ezradio_crcerror_plugin.c ezradio_auto_ack_plugin.c ezradio_unmod_carrier_plugin.c ezradio_pn9_plugin.c ezradio_direct_transmit_plugin.c ezradio_direct_receive_plugin.c
  group gpiointerrupt
    ../../../../../emdrv/gpiointerrupt/src/: gpiointerrupt.c
  group rtcdrv
    ../../../../../emdrv/rtcdrv/src/: rtcdriver.c
  group spidrv
    ../../../../../emdrv/spidrv/src/: spidrv.c
  group ustimer
    ../../../../../emdrv/ustimer/src/: ustimer.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_emu.c em_dma.c em_gpio.c em_int.c em_pcnt.c em_prs.c em_rtc.c em_system.c em_timer.c em_usart.c
  group Source
    ../: main.c
