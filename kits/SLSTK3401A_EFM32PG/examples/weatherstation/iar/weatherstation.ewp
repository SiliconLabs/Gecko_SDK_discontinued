# IAR project weatherstation.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32PG1B200F256GM48 SiliconLaboratories EFM32PG1B200F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32PG1B200F256GM48; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\SiliconLabs\EFM32PG1B\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\..\emdrv\common\inc; ..\..\..\..\..\emdrv\rtcdrv\inc; ..\..\..\..\common\drivers; ..\..\..\..\common\bsp; ..\..\..\config; ..\..\..\..\..\reptile\glib; ..\..\..\..\..\reptile\glib\glib; ..\..\..\..\..\reptile\glib\dmd; ..; ..\..\..\..\..\emdrv\config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: weatherstation.bin
  ILINK.IlinkOutputFile: weatherstation.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32PG1B200F256GM48; DEBUG_EFM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32PG1B/Source/IAR/: startup_efm32pg1b.s
    ../../../../../Device/SiliconLabs/EFM32PG1B/Source/: system_efm32pg1b.c
  group bsp
    ../../../../common/bsp/: bsp_bcc.c bsp_stk.c
  group emdrv
    ../../../../../emdrv/rtcdrv/src/: rtcdriver.c
  group Drivers
    ../../../../common/drivers/: display.c displayls013b7dh03.c displaypalemlib.c udelay.c si7013.c si114x_algorithm.c si114x_functions.c si1147_i2c.c i2cspm.c
  group glib
    ../../../../../reptile/glib/dmd/display/: dmd_display.c
    ../../../../../reptile/glib/glib/: glib.c glib_bitmap.c glib_circle.c glib_line.c glib_rectangle.c glib_string.c glib_font_normal_8x8.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_system.c em_cmu.c em_emu.c em_gpio.c em_int.c em_leuart.c em_rtcc.c em_usart.c em_i2c.c
  group Source
    ../: weatherstation.c background.c graphics.c
