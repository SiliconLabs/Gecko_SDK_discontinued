# Keil uVision project cpt007b_demo.uvprojx, settings and files
target cpt007b_demo (ARM-ADS)
  device: EFM32PG1B200F256GM48 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(38400000) CPUTYPE("Cortex-M4") FPU2
  output: cpt007b_demo
  AfterMake: fromelf.exe --bin --output obj\cpt007b_demo.bin obj\cpt007b_demo.axf
  c flags: Optim=1 uC99=1 wLevel=2
  c define: EFM32PG1B200F256GM48 DEBUG_EFM
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32PG1B\Include;..\..\..\..\..\emlib\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config;..\..\..\..\..\reptile\glib;..\..\..\..\..\reptile\glib\dmd;..\..\..\..\..\reptile\glib\dmd\ssd2119;..\..\..\..\..\reptile\glib\glib;..;..\Drivers;..\img
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32PG1B/Source/ARM/: startup_efm32pg1b.s
    ../../../../../Device/SiliconLabs/EFM32PG1B/Source/: system_efm32pg1b.c
  group Drivers
    ../../../../common/drivers/: display.c displayls013b7dh03.c displaypalemlib.c udelay.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_int.c em_lcd.c em_prs.c em_rtcc.c em_system.c em_usart.c
  group img
    ../img/: out_disable.xbm out_on.xbm out_off.xbm
  group Source
    ../: cpt007b_demo.c displayconfigapp.h
    ../Drivers/: gpio.c gpio.h lcd.c lcd.h render.c render.h
