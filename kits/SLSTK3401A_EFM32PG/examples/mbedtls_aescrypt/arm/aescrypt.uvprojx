# Keil uVision project aescrypt.uvprojx, settings and files
target aescrypt (ARM-ADS)
  device: EFM32PG1B200F256GM48 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(38400000) CPUTYPE("Cortex-M4") FPU2
  output: aescrypt
  AfterMake: fromelf.exe --bin --output obj\aescrypt.bin obj\aescrypt.axf
  c flags: Optim=4 oTime=1 uC99=1 wLevel=2
  c define: EFM32PG1B200F256GM48 DEBUG_EFM RETARGET_VCOM
  c misc: -DMBEDTLS_CONFIG_FILE='"config-aescrypt.h"'
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32PG1B\Include;..\..\..\..\..\emlib\inc;..\..\..\..\..\reptile\mbedtls\include;..\..\..\..\..\reptile\mbedtls\include\mbedtls;..\..\..\..\..\reptile\mbedtls\sl_crypto;..\..\..\..\common\bsp;..\..\..\..\common\drivers;..\..\..\config;..
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group cmsis
    ../../../../../Device/SiliconLabs/EFM32PG1B/Source/ARM/: startup_efm32pg1b.s
    ../../../../../Device/SiliconLabs/EFM32PG1B/Source/: system_efm32pg1b.c
  group mbedtls
    ../../../../../reptile/mbedtls/library/: aes.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c cipher.c cipher_wrap.c ctr_drbg.c des.c dhm.c ecdh.c ecdsa.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c oid.c pem.c pk.c pk_wrap.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c threading.c timing.c version.c version_features.c xtea.c
  group sl_crypto
    ../../../../../reptile/mbedtls/sl_crypto/: sl_aes.c sl_ecp.c sl_sha1.c sl_sha256.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_system.c em_cmu.c em_emu.c em_gpio.c em_int.c em_usart.c
  group Drivers
    ../../../../common/drivers/: retargetio.c retargetserial.c
  group test
    ../: main.c
