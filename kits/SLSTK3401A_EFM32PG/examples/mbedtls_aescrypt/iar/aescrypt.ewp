# IAR project aescrypt.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32PG1B200F256GM48 SiliconLaboratories EFM32PG1B200F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: EFM32PG1B200F256GM48; DEBUG_EFM; RETARGET_VCOM; MBEDTLS_CONFIG_FILE="config-sl-crypto-all-acceleration.h"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\SiliconLabs\EFM32PG1B\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\..\emdrv\common\inc; ..\..\..\..\..\util\third_party\mbedtls\configs; ..\..\..\..\..\util\third_party\mbedtls\include; ..\..\..\..\..\util\third_party\mbedtls\include\mbedtls; ..\..\..\..\..\util\third_party\mbedtls\sl_crypto\include; ..\..\..\..\common\bsp; ..\..\..\..\common\drivers; ..\..\..\config; ..
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: aescrypt.bin
  ILINK.IlinkOutputFile: aescrypt.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32PG1B200F256GM48; DEBUG_EFM; RETARGET_VCOM; MBEDTLS_CONFIG_FILE="config-sl-crypto-all-acceleration.h"
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group cmsis
    ../../../../../Device/SiliconLabs/EFM32PG1B/Source/IAR/: startup_efm32pg1b.s
    ../../../../../Device/SiliconLabs/EFM32PG1B/Source/: system_efm32pg1b.c
  group Drivers
    ../../../../common/drivers/: retargetio.c retargetserial.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_crypto.c em_emu.c em_gpio.c em_int.c em_system.c em_usart.c
  group mbedtls
    ../../../../../util/third_party/mbedtls/library/: aes.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c cipher.c cipher_wrap.c ctr_drbg.c des.c dhm.c ecdh.c ecdsa.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c oid.c pem.c pk.c pk_wrap.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c threading.c timing.c version.c version_features.c xtea.c
  group sl_crypto
    ../../../../../util/third_party/mbedtls/sl_crypto/src/: sl_aes.c sl_ecp.c sl_sha1.c sl_sha256.c
  group test
    ../: main.c
