# Keil uVision project spaceinvaders.uvprojx, settings and files
target spaceinvaders (ARM-ADS)
  device: EFM32PG1B200F256GM48 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(38400000) CPUTYPE("Cortex-M4") FPU2
  output: spaceinvaders
  AfterMake: fromelf.exe --bin --output obj\spaceinvaders.bin obj\spaceinvaders.axf
  c flags: Optim=4 oTime=1 uC99=1 wLevel=2
  c define: EFM32PG1B200F256GM48 DEBUG_EFM
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32PG1B\Include;..\..\..\..\..\emlib\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\..\..\reptile\glib;..\..\..\config;..
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32PG1B/Source/ARM/: startup_efm32pg1b.s
    ../../../../../Device/SiliconLabs/EFM32PG1B/Source/: system_efm32pg1b.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_acmp.c em_system.c em_cmu.c em_emu.c em_gpio.c em_int.c em_usart.c em_prs.c em_rtcc.c
  group Drivers
    ../../../../common/drivers/: capsense.c display.c displayls013b7dh03.c displaypalemlib.c udelay.c
  group Source
    ../: main.c render.c game.c spaceinvaders.c
