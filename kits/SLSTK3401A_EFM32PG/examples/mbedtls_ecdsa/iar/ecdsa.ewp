# IAR project ecdsa.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32PG1B200F256GM48 SiliconLaboratories EFM32PG1B200F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32PG1B200F256GM48; DEBUG_EFM; RETARGET_VCOM; MBEDTLS_CONFIG_FILE="config-ecdsa.h"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\SiliconLabs\EFM32PG1B\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\..\reptile\mbedtls\include; ..\..\..\..\..\reptile\mbedtls\include\mbedtls; ..\..\..\..\..\reptile\mbedtls\sl_crypto; ..\..\..\..\common\bsp; ..\..\..\..\common\drivers; ..\..\..\config; ..
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ecdsa.bin
  ILINK.IlinkOutputFile: ecdsa.out
  ILINK.IlinkIcfFile: ..\ecdsa.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32PG1B200F256GM48; DEBUG_EFM; RETARGET_VCOM; MBEDTLS_CONFIG_FILE="config-ecdsa.h"
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group cmsis
    ../../../../../Device/SiliconLabs/EFM32PG1B/Source/IAR/: startup_efm32pg1b.s
    ../../../../../Device/SiliconLabs/EFM32PG1B/Source/: system_efm32pg1b.c
  group mbedtls
    ../../../../../reptile/mbedtls/library/: aes.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c cipher.c cipher_wrap.c ctr_drbg.c des.c dhm.c ecdh.c ecdsa.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c oid.c pem.c pk.c pk_wrap.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c threading.c timing.c version.c version_features.c xtea.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_crypto.c em_cmu.c em_system.c em_emu.c em_gpio.c em_int.c em_usart.c
  group sl_crypto
    ../../../../../reptile/mbedtls/sl_crypto/: sl_ecp.c sl_aes.c sl_sha1.c sl_sha256.c
  group Drivers
    ../../../../common/drivers/: retargetio.c retargetserial.c
  group test
    ../: main.c dummy_entropy.c
