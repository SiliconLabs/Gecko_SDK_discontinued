# IAR project cpt112s_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32PG1B200F256GM48 SiliconLaboratories EFM32PG1B200F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32PG1B200F256GM48; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\SiliconLabs\EFM32PG1B\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\common\drivers; ..\..\..\..\common\bsp; ..\..\..\config; ..\..\..\..\..\reptile\glib; ..\..\..\..\..\reptile\glib\dmd; ..\..\..\..\..\reptile\glib\dmd\ssd2119; ..\..\..\..\..\reptile\glib\glib; ..; ..\Drivers; ..\img
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cpt112s_demo.bin
  ILINK.IlinkOutputFile: cpt112s_demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32PG1B200F256GM48; DEBUG_EFM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32PG1B/Source/IAR/: startup_efm32pg1b.s
    ../../../../../Device/SiliconLabs/EFM32PG1B/Source/: system_efm32pg1b.c
  group Drivers
    ../../../../common/drivers/: cpt112s_i2c.c display.c displayls013b7dh03.c displaypalemlib.c udelay.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_i2c.c em_int.c em_prs.c em_rtcc.c em_system.c em_usart.c
  group img
    ../img/: circle.xbm out_disable.xbm out_on.xbm out_off.xbm
  group Source
    ../: cpt112s_demo.c displayconfigapp.h
    ../Drivers/: render.c render.h lcd.c lcd.h
