# Keil uVision project rtx_blink.uvprojx, settings and files
target rtx_blink (ARM-ADS)
  device: EFM32PG1B200F256GM48 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(38400000) CPUTYPE("Cortex-M4") FPU2
  output: rtx_blink
  AfterMake: fromelf.exe --bin --output obj\rtx_blink.bin obj\rtx_blink.axf
  c flags: Optim=4 oTime=1 uC99=1 wLevel=2
  c define: EFM32PG1B200F256GM48
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32PG1B\Include;..\..\..\..\..\emlib\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\..\..\reptile\RTX\Inc;..\..\..\config
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32PG1B/Source/ARM/: startup_efm32pg1b.s
    ../../../../../Device/SiliconLabs/EFM32PG1B/Source/: system_efm32pg1b.c
  group BSP
    ../../../../common/bsp/: bsp_stk_leds.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_system.c
  group Source
    ../: rtx_blink.c RTX_Conf_CM.c
  group Libraries
    ../../../../../reptile/RTX/LIB/ARM/: RTX_CM4.lib
