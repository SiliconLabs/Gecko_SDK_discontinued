# Keil uVision project nvm_simple.uvprojx, settings and files
target nvm_simple (ARM-ADS)
  device: EFM32TG840F32 Silicon Labs
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(14000000) CPUTYPE("Cortex-M3")
  output: nvm_simple
  AfterMake: fromelf.exe --bin --output obj\nvm_simple.bin obj\nvm_simple.axf
  c flags: Optim=4 oTime=1
  c define: EFM32TG840F32 DEBUG_EFM
  c misc: --c99
  c include: ..\;..;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32TG\Include;..\..\..\..\..\emlib\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config;..\..\..\..\..\emdrv\nvm\inc;..\..\..\..\..\emdrv\common\inc
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: ram_code.sct
  group bsp
    ../../../../common/bsp/: bsp_trace.c bsp_stk_leds.c
  group Drivers
    ../../../../../emdrv/nvm/src/: nvm.c nvm_hal.c
    ../../../../common/drivers/: segmentlcd.c
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32TG/Source/ARM/: startup_efm32tg.s
    ../../../../../Device/SiliconLabs/EFM32TG/Source/: system_efm32tg.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_int.c em_system.c em_msc.c em_lcd.c
  group Source
    ../: main.c nvm_config.c
