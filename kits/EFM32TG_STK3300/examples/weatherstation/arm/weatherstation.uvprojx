# Keil uVision project weatherstation.uvprojx, settings and files
target weatherstation (ARM-ADS)
  device: EFM32TG840F32 Silicon Labs
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(14000000) CPUTYPE("Cortex-M3")
  output: weatherstation
  AfterMake: fromelf.exe --bin --output obj\weatherstation.bin obj\weatherstation.axf
  c flags: Optim=4
  c define: EFM32TG840F32
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32TG\Include;..\..\..\..\..\emlib\inc;..\..\..\..\..\emdrv\common\inc;..\..\..\..\..\emdrv\rtcdrv\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config;..\..\..\..\..\reptile\glib;..\..\..\..\..\reptile\glib\glib;..\..\..\..\..\reptile\glib\dmd;..;..\..\..\..\..\emdrv\config
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32TG/Source/ARM/: startup_efm32tg.s
    ../../../../../Device/SiliconLabs/EFM32TG/Source/: system_efm32tg.c
  group bsp
    ../../../../common/bsp/: bsp_trace.c
  group emdrv
    ../../../../../emdrv/rtcdrv/src/: rtcdriver.c
  group Drivers
    ../../../../common/drivers/: segmentlcd.c si7013.c si114x_algorithm.c si114x_functions.c si1147_i2c.c i2cspm.c vddcheck.c
  group emlib
    ../../../../../emlib/src/: em_adc.c em_assert.c em_cmu.c em_emu.c em_gpio.c em_int.c em_lcd.c em_rtc.c em_system.c em_i2c.c em_vcmp.c
  group Source
    ../: weatherstation.c graphics.c
