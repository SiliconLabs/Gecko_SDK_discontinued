# IAR project weatherstation.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32TG840F32 SiliconLaboratories EFM32TG840F32
  ICCARM.CCDefines: EFM32TG840F32
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\SiliconLabs\EFM32TG\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\..\emdrv\common\inc; ..\..\..\..\..\emdrv\rtcdrv\inc; ..\..\..\..\common\drivers; ..\..\..\..\common\bsp; ..\..\..\config; ..\..\..\..\..\reptile\glib; ..\..\..\..\..\reptile\glib\glib; ..\..\..\..\..\reptile\glib\dmd; ..; ..\..\..\..\..\emdrv\config
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: weatherstation.bin
  ILINK.IlinkOutputFile: weatherstation.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32TG840F32
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32TG/Source/IAR/: startup_efm32tg.s
    ../../../../../Device/SiliconLabs/EFM32TG/Source/: system_efm32tg.c
  group bsp
    ../../../../common/bsp/: bsp_trace.c
  group emdrv
    ../../../../../emdrv/rtcdrv/src/: rtcdriver.c
  group Drivers
    ../../../../common/drivers/: segmentlcd.c si7013.c si114x_algorithm.c si114x_functions.c si1147_i2c.c i2cspm.c vddcheck.c
  group emlib
    ../../../../../emlib/src/: em_adc.c em_assert.c em_cmu.c em_emu.c em_gpio.c em_int.c em_lcd.c em_rtc.c em_system.c em_i2c.c em_vcmp.c
  group Source
    ../: weatherstation.c graphics.c
