# IAR project touch.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32TG840F32 SiliconLaboratories EFM32TG840F32
  ICCARM.CCDefines: EFM32TG840F32
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\SiliconLabs\EFM32TG\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\common\drivers; ..\..\..\..\common\bsp; ..\..\..\config; ..\..\..\..\..\emdrv\common\inc; ..\..\..\..\..\emdrv\rtcdrv\inc; ..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: touch.bin
  ILINK.IlinkOutputFile: touch.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32TG840F32
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32TG/Source/IAR/: startup_efm32tg.s
    ../../../../../Device/SiliconLabs/EFM32TG/Source/: system_efm32tg.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_acmp.c em_cmu.c em_emu.c em_gpio.c em_int.c em_lesense.c em_rtc.c em_system.c em_lcd.c em_vcmp.c
  group Drivers
    ../../../../common/drivers/: vddcheck.c segmentlcd.c caplesense.c
  group emdrv
    ../../../../../emdrv/rtcdrv/src/: rtcdriver.c
  group BSP
    ../../../../common/bsp/: bsp_trace.c
  group Source
    ../: touchdemo.c
