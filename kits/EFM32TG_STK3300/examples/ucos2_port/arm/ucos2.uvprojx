# Keil uVision project ucos2.uvprojx, settings and files
target ucos2 (ARM-ADS)
  device: EFM32TG840F32 Silicon Labs
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(14000000) CPUTYPE("Cortex-M3")
  output: ucos2
  AfterMake: fromelf.exe --bin --output obj\ucos2.bin obj\ucos2.axf
  c flags: Optim=4 oTime=1
  c define: EFM32TG840F32
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32TG\Include;..\..\..\..\..\emlib\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config;..\src\bsp;..\src\app;..\..\..\..\..\reptile\Micrium\uCOS-II\uC-CPU;..\..\..\..\..\reptile\Micrium\uCOS-II\uC-LIB;..\..\..\..\..\reptile\Micrium\uCOS-II\uCOS-II\Source;..\..\..\..\..\reptile\Micrium\uCOS-II\uC-CPU\ARM-Cortex-M3\RealView;..\..\..\..\..\reptile\Micrium\uCOS-II\uCOS-II\Ports\ARM-Cortex-M3\Generic\RealView
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group APP
    ../src/app/: app.c app_hooks.c app_task_one.c app_task_two.c app_task_three.c
  group BSP
    ../src/bsp/: bspos.c
  group BSP-STK
    ../../../../common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32TG/Source/: system_efm32tg.c
    ../../../../../reptile/Micrium/uCOS-II/startup/EFM32TG/arm/: startup_efm32tg.s
  group Drivers
    ../../../../common/drivers/: retargetio.c retargetserial.c segmentlcd.c
  group emlib
    ../../../../../emlib/src/: em_cmu.c em_emu.c em_gpio.c em_lcd.c em_system.c em_usart.c em_leuart.c em_int.c
  group uC/CPU
    ../../../../../reptile/Micrium/uCOS-II/uC-CPU/: cpu_core.c
    ../../../../../reptile/Micrium/uCOS-II/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
  group uC/LIB
    ../../../../../reptile/Micrium/uCOS-II/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uC/OS-II
    ../../../../../reptile/Micrium/uCOS-II/uCOS-II/Source/: ucos_ii.c
    ../../../../../reptile/Micrium/uCOS-II/uCOS-II/Ports/ARM-Cortex-M3/Generic/RealView/: os_dbg.c os_cpu_c.c os_cpu_a.asm
