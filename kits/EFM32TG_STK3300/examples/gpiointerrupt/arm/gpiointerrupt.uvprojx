# Keil uVision project gpiointerrupt.uvprojx, settings and files
target gpiointerrupt (ARM-ADS)
  device: EFM32TG840F32 Silicon Labs
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(14000000) CPUTYPE("Cortex-M3")
  output: gpiointerrupt
  AfterMake: fromelf.exe --bin --output obj\gpiointerrupt.bin obj\gpiointerrupt.axf
  c flags: Optim=1
  c define: EFM32TG840F32 DEBUG_EFM
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32TG\Include;..\..\..\..\..\emlib\inc;..\..\..\..\..\emdrv\gpiointerrupt\inc;..\..\..\..\common\bsp;..\..\..\config
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32TG/Source/ARM/: startup_efm32tg.s
    ../../../../../Device/SiliconLabs/EFM32TG/Source/: system_efm32tg.c
  group bsp
    ../../../../common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_ebi.c em_emu.c em_gpio.c em_int.c em_usart.c em_system.c
  group emdrv
    ../../../../../emdrv/gpiointerrupt/src/: gpiointerrupt.c
  group Source
    ../: main.c
