# Keil uVision project emlcd.uvprojx, settings and files
target emlcd (ARM-ADS)
  device: EFM32TG840F32 Silicon Labs
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(14000000) CPUTYPE("Cortex-M3")
  output: emlcd
  AfterMake: fromelf.exe --bin --output obj\emlcd.bin obj\emlcd.axf
  c flags: Optim=4 oTime=1
  c define: EFM32TG840F32 DEBUG_EFM
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32TG\Include;..\..\..\..\..\emlib\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config;..\..\..\..\..\emdrv\common\inc;..\..\..\..\..\emdrv\rtcdrv\inc;..
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32TG/Source/ARM/: startup_efm32tg.s
    ../../../../../Device/SiliconLabs/EFM32TG/Source/: system_efm32tg.c
  group Drivers
    ../../../../common/drivers/: vddcheck.c segmentlcd.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_lcd.c em_rtc.c em_system.c em_vcmp.c em_int.c
  group emdrv
    ../../../../../emdrv/rtcdrv/src/: rtcdriver.c
  group BSP
    ../../../../common/bsp/: bsp_trace.c
  group Source
    ../: emlcd.c lcdtest.c
