# IAR project blink.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EZR32HG320F64R68 SiliconLaboratories EZR32HG320F64R68
  ICCARM.CCDefines: EZR32HG320F64R68; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\SiliconLabs\EZR32HG\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\common\bsp; ..\..\..\config
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: blink.bin
  ILINK.IlinkOutputFile: blink.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EZR32HG320F64R68; DEBUG_EFM
  group CMSIS
    ../../../../../Device/SiliconLabs/EZR32HG/Source/IAR/: startup_ezr32hg.s
    ../../../../../Device/SiliconLabs/EZR32HG/Source/: system_ezr32hg.c
  group bsp
    ../../../../common/bsp/: bsp_stk_leds.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c
  group Source
    ../: blink.c
