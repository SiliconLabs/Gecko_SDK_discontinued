# Keil uVision project clock.uvprojx, settings and files
target clock (ARM-ADS)
  device: EZR32LG330F256R55 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: clock
  AfterMake: fromelf.exe --bin --output obj\clock.bin obj\clock.axf
  c flags: Optim=4
  c define: EZR32LG330F256R55
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EZR32LG\Include;..\..\..\..\..\emlib\inc;..\..\..\..\..\kits\common\drivers;..\..\..\..\..\reptile\glib;..\..\..\..\..\reptile\glib\glib;..\..\..\..\..\reptile\glib\dmd;..\..\..\..\..\kits\common\bsp;..\..\..\config;..
  asm define: EZR32LG330F256R55
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../../../Device/SiliconLabs/EZR32LG/Source/ARM/: startup_ezr32lg.s
    ../../../../../Device/SiliconLabs/EZR32LG/Source/: system_ezr32lg.c
  group Drivers
    ../../../../../kits/common/drivers/: display.c displayls013b7dh03.c displaypalemlib.c retargetio.c retargettextdisplay.c textdisplay.c udelay.c
  group glib
    ../../../../../reptile/glib/dmd/display/: dmd_display.c
    ../../../../../reptile/glib/glib/: glib.c glib_bitmap.c glib_circle.c glib_line.c glib_rectangle.c glib_string.c glib_font_normal_8x8.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_int.c em_pcnt.c em_prs.c em_rtc.c em_system.c em_usart.c
  group Source
    ../: main.c analog_clock.c
