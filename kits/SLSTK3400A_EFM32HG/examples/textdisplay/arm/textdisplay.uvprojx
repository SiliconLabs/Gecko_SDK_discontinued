# Keil uVision project textdisplay.uvprojx, settings and files
target textdisplay (ARM-ADS)
  device: EFM32HG322F64 Silicon Labs
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(24000000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: textdisplay
  AfterMake: fromelf.exe --bin --output obj\textdisplay.bin obj\textdisplay.axf
  c flags: Optim=4 oTime=1
  c define: EFM32HG322F64 DEBUG_EFM
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32HG\Include;..\..\..\..\..\emlib\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config;..;..\..\..\..\..\reptile\glib
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32HG/Source/ARM/: startup_efm32hg.s
    ../../../../../Device/SiliconLabs/EFM32HG/Source/: system_efm32hg.c
  group bsp
    ../../../../common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c
  group Drivers
    ../../../../common/drivers/: retargetio.c retargettextdisplay.c textdisplay.c display.c displayls013b7dh03.c displaypalemlib.c udelay.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_emu.c em_ebi.c em_gpio.c em_int.c em_prs.c em_rtc.c em_system.c em_leuart.c em_usart.c
  group Source
    ../: main.c
