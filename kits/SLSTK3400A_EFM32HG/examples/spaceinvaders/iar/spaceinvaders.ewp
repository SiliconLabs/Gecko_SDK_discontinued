# IAR project spaceinvaders.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32HG322F64 SiliconLaboratories EFM32HG322F64
  ICCARM.CCDefines: EFM32HG322F64; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\SiliconLabs\EFM32HG\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\common\drivers; ..\..\..\..\common\bsp; ..\..\..\..\..\reptile\glib; ..\..\..\config; ..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: spaceinvaders.bin
  ILINK.IlinkOutputFile: spaceinvaders.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32HG322F64; DEBUG_EFM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32HG/Source/IAR/: startup_efm32hg.s
    ../../../../../Device/SiliconLabs/EFM32HG/Source/: system_efm32hg.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_acmp.c em_system.c em_cmu.c em_emu.c em_gpio.c em_int.c em_usart.c em_prs.c em_rtc.c
  group Drivers
    ../../../../common/drivers/: display.c displayls013b7dh03.c displaypalemlib.c udelay.c
  group Source
    ../: main.c render.c game.c spaceinvaders.c
    ../drivers/: capsense_spaceinvaders.c
