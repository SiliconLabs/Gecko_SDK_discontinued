# IAR project cpt007b_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32HG322F64 SiliconLaboratories EFM32HG322F64
  ICCARM.CCDefines: EFM32HG322F64; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\SiliconLabs\EFM32HG\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\common\drivers; ..\..\..\..\common\bsp; ..\..\..\config; ..\..\..\..\..\reptile\glib; ..\..\..\..\..\reptile\glib\dmd; ..\..\..\..\..\reptile\glib\dmd\ssd2119; ..\..\..\..\..\reptile\glib\glib; ..\..\..\..\..\reptile\glib\glib; ..\..\..\..\..\reptile\glib\glib; ..; ..\Drivers; ..\img
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cpt007b_demo.bin
  ILINK.IlinkOutputFile: cpt007b_demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32HG322F64; DEBUG_EFM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32HG/Source/IAR/: startup_efm32hg.s
    ../../../../../Device/SiliconLabs/EFM32HG/Source/: system_efm32hg.c
  group Drivers
    ../../../../common/drivers/: display.c displayls013b7dh03.c displaypalemlib.c udelay.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_int.c em_lcd.c em_prs.c em_rtc.c em_system.c em_usart.c
  group img
    ../img/: out_disable.xbm out_on.xbm out_off.xbm
  group Source
    ../: cpt007b_demo.c displayconfigapp.h
    ../Drivers/: gpio.c gpio.h lcd.c lcd.h render.c render.h
