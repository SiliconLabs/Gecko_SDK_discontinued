# Keil uVision project temperature.uvprojx, settings and files
target temperature (ARM-ADS)
  device: EFM32LG990F256 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: temperature
  AfterMake: fromelf.exe --bin --output obj\temperature.bin obj\temperature.axf
  c flags: Optim=4 oTime=1
  c define: EFM32LG990F256 DEBUG_EFM
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32LG\Include;..\..\..\..\..\emlib\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config;..\..\..\..\..\reptile\glib;..\..\..\..\..\emdrv\common\inc;..\..\..\..\..\emdrv\rtcdrv\inc;..
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32LG/Source/ARM/: startup_efm32lg.s
    ../../../../../Device/SiliconLabs/EFM32LG/Source/: system_efm32lg.c
  group bsp
    ../../../../common/bsp/: bsp_dk_3201.c bsp_dk_leds.c bsp_trace.c
  group Drivers
    ../../../../common/drivers/: i2cspm.c retargetio.c retargettft.c tempsens.c
    ../../../../../reptile/glib/dmd/ssd2119/: dmd_ssd2119_16bit.c dmdif_ssd2119_ebi16.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_ebi.c em_emu.c em_gpio.c em_i2c.c em_rtc.c em_system.c em_usart.c em_int.c
  group emdrv
    ../../../../../emdrv/rtcdrv/src/: rtcdriver.c
  group Source
    ../: temperature.c
