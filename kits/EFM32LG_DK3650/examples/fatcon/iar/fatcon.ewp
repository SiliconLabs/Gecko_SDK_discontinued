# IAR project fatcon.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32LG990F256 SiliconLaboratories EFM32LG990F256
  ICCARM.CCDefines: EFM32LG990F256; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\SiliconLabs\EFM32LG\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\common\drivers; ..\..\..\..\common\bsp; ..\..\..\config; ..\..\..\..\..\reptile\fatfs\inc; ..\..\..\..\..\reptile\glib
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: fatcon.bin
  ILINK.IlinkOutputFile: fatcon.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32LG990F256; DEBUG_EFM
  group bsp
    ../../../../common/bsp/: bsp_dk_3201.c bsp_trace.c
  group drivers
    ../../../../common/drivers/: retargetio.c retargetserial.c microsd.c
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32LG/Source/IAR/: startup_efm32lg.s
    ../../../../../Device/SiliconLabs/EFM32LG/Source/: system_efm32lg.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_ebi.c em_emu.c em_gpio.c em_int.c em_system.c em_usart.c
  group FatFS
    ../../../../../reptile/fatfs/src/: diskio.c ff.c
  group Source
    ../: fatcon.c
