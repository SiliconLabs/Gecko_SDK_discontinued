# Keil uVision project nandflash.uvprojx, settings and files
target nandflash (ARM-ADS)
  device: EFM32LG990F256 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: nandflash
  AfterMake: fromelf.exe --bin --output obj\nandflash.bin obj\nandflash.axf
  c flags: Optim=4 oTime=1
  c define: EFM32LG990F256 DEBUG_EFM
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32LG\Include;..\..\..\..\..\emlib\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config
  asm define: EFM32LG990F256 DEBUG_EFM
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group bsp
    ../../../../common/bsp/: bsp_bcc.c bsp_stk.c bsp_trace.c
  group Drivers
    ../../../../common/drivers/: dmactrl.c nandflash.c retargetio.c retargetserial.c
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32LG/Source/ARM/: startup_efm32lg.s
    ../../../../../Device/SiliconLabs/EFM32LG/Source/: system_efm32lg.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_int.c em_system.c em_usart.c
  group Source
    ../: main.c
