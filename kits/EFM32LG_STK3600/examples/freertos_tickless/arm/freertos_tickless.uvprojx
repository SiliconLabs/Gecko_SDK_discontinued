# Keil uVision project freertos_tickless.uvprojx, settings and files
target freertos_tickless (ARM-ADS)
  device: EFM32LG990F256 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: freertos_tickless
  AfterMake: fromelf.exe --bin --output obj\freertos_tickless.bin obj\freertos_tickless.axf
  c flags: Optim=4 oTime=1
  c define: EFM32LG990F256 RVDS_ARMCM3_LM3S102 DEBUG_EFM
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32LG\Include;..\..\..\..\..\emlib\inc;..\..\..\..\..\emdrv\sleep\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..;..\..\..\..\..\reptile\FreeRTOS\Source\include;..\..\..\..\..\reptile\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\..\config
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32LG/Source/ARM/: startup_efm32lg.s
    ../../../../../Device/SiliconLabs/EFM32LG/Source/: system_efm32lg.c
  group Drivers
    ../../../../common/drivers/: segmentlcd.c
  group BSP
    ../../../../common/bsp/: bsp_trace.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_burtc.c em_cmu.c em_emu.c em_gpio.c em_int.c em_lcd.c em_rmu.c em_rtc.c em_system.c
  group emdrv
    ../../../../../emdrv/sleep/src/: sleep.c
  group FreeRTOS
    ../../../../../reptile/FreeRTOS/Source/: timers.c tasks.c queue.c list.c croutine.c event_groups.c
    ../../../../../reptile/FreeRTOS/Source/portable/MemMang/: heap_1.c
    ../../../../../reptile/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Source
    ../: main.c low_power_tick_management.c
