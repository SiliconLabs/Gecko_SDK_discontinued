# Keil uVision project mpu.uvprojx, settings and files
target mpu (ARM-ADS)
  device: EFM32LG990F256 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: mpu
  AfterMake: fromelf.exe --bin --output obj\mpu.bin obj\mpu.axf
  c flags: Optim=1 oTime=1
  c define: EFM32LG990F256
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32LG\Include;..\..\..\..\..\emlib\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config;..\..\..\..\..\emdrv\common\inc;..\..\..\..\..\emdrv\rtcdrv\inc;..
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32LG/Source/ARM/: startup_efm32lg.s
    ../../../../../Device/SiliconLabs/EFM32LG/Source/: system_efm32lg.c
  group Drivers
    ../../../../common/drivers/: segmentlcd.c
  group BSP
    ../../../../common/bsp/: bsp_trace.c
  group emlib
    ../../../../../emlib/src/: em_cmu.c em_emu.c em_gpio.c em_lcd.c em_mpu.c em_rtc.c em_system.c em_int.c
  group emdrv
    ../../../../../emdrv/rtcdrv/src/: rtcdriver.c
  group Source
    ../: mpu.c
