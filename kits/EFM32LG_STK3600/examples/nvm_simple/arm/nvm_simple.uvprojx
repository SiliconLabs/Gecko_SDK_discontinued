# Keil uVision project nvm_simple.uvprojx, settings and files
target nvm_simple (ARM-ADS)
  device: EFM32LG990F256 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: nvm_simple
  AfterMake: fromelf.exe --bin --output obj\nvm_simple.bin obj\nvm_simple.axf
  c flags: Optim=4 oTime=1
  c define: EFM32LG990F256 DEBUG_EFM
  c misc: --c99
  c include: ..\;..;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32LG\Include;..\..\..\..\..\emlib\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config;..\..\..\..\..\emdrv\nvm\inc;..\..\..\..\..\emdrv\common\inc
  asm define: EFM32LG990F256 DEBUG_EFM
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ram_code.sct
  group bsp
    ../../../../common/bsp/: bsp_trace.c bsp_stk_leds.c
  group Drivers
    ../../../../../emdrv/nvm/src/: nvm.c nvm_hal.c
    ../../../../common/drivers/: segmentlcd.c
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32LG/Source/ARM/: startup_efm32lg.s
    ../../../../../Device/SiliconLabs/EFM32LG/Source/: system_efm32lg.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_int.c em_system.c em_msc.c em_lcd.c
  group Source
    ../: main.c nvm_config.c
