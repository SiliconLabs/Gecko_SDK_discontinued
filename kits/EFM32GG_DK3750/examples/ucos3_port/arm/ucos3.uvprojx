# Keil uVision project ucos3.uvprojx, settings and files
target ucos3 (ARM-ADS)
  device: EFM32GG990F1024 Silicon Labs
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0xFFFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: ucos3
  AfterMake: fromelf.exe --bin --output obj\ucos3.bin obj\ucos3.axf
  c flags: Optim=4
  c define: EFM32GG990F1024
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32GG\Include;..\..\..\..\..\emlib\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config;..\src\bsp;..\src\app;..\..\..\..\..\reptile\glib;..\..\..\..\..\reptile\Micrium\uCOS-III\uC-CPU;..\..\..\..\..\reptile\Micrium\uCOS-III\uC-LIB;..\..\..\..\..\reptile\Micrium\uCOS-III\uCOS-III\Source;..\..\..\..\..\reptile\Micrium\uCOS-III\uC-CPU\ARM-Cortex-M3\RealView;..\..\..\..\..\reptile\Micrium\uCOS-III\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group APP
    ../src/app/: app.c app_hooks.c app_task_one.c app_task_two.c app_task_three.c
  group BSP-DVK
    ../src/bsp/: bsp-uart.c
    ../../../../common/bsp/: bsp_dk_3201.c bsp_dk_leds.c bsp_trace.c
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32GG/Source/: system_efm32gg.c
    ../../../../../reptile/Micrium/uCOS-III/startup/EFM32GG/arm/: startup_efm32gg.s
  group Drivers
    ../../../../common/drivers/: retargetio.c retargettft.c
  group Graphics
    ../../../../../reptile/glib/dmd/ssd2119/: dmd_ssd2119_16bit.c dmdif_ssd2119_ebi16.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_emu.c em_ebi.c em_gpio.c em_system.c em_usart.c em_leuart.c em_int.c
  group uC/CPU
    ../../../../../reptile/Micrium/uCOS-III/uC-CPU/: cpu_core.c
    ../../../../../reptile/Micrium/uCOS-III/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
  group uC/OS-III
    ../../../../../reptile/Micrium/uCOS-III/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../../../../../reptile/Micrium/uCOS-III/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_c.c os_cpu_a.s
