# Keil uVision project usbdmicrophone.uvprojx, settings and files
target usbdmicrophone (ARM-ADS)
  device: EFM32GG990F1024 Silicon Labs
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0xFFFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: usbdmicrophone
  AfterMake: fromelf.exe --bin --output obj\usbdmicrophone.bin obj\usbdmicrophone.axf
  c flags: Optim=1
  c define: EFM32GG990F1024 DEBUG_EFM_USER
  c misc: --c99
  c include: ..\;..;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32GG\Include;..\..\..\..\..\emlib\inc;..\..\..\..\..\usb\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config;..\..\..\..\..\emdrv\common\inc;..\..\..\..\..\emdrv\dmadrv\inc
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32GG/Source/ARM/: startup_efm32gg.s
    ../../../../../Device/SiliconLabs/EFM32GG/Source/: system_efm32gg.c
  group bsp
    ../../../../common/bsp/: bsp_dk_3201.c bsp_trace.c
  group emdrv
    ../../../../../emdrv/dmadrv/src/: dmadrv.c
  group drivers
    ../../../../common/drivers/: retargetio.c retargetserial.c dmactrl.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_adc.c em_cmu.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_int.c em_prs.c em_system.c em_timer.c em_usart.c
  group emusb
    ../../../../../usb/src/: em_usbd.c em_usbdch9.c em_usbhal.c em_usbdep.c em_usbdint.c em_usbtimer.c
  group Source
    ../: main.c descriptors.c
