# Keil uVision project emode.uvprojx, settings and files
target emode (ARM-ADS)
  device: EFM32GG990F1024 Silicon Labs
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0xFFFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: emode
  AfterMake: fromelf.exe --bin --output obj\emode.bin obj\emode.axf
  c flags: Optim=4 oTime=1
  c define: EFM32GG990F1024 DEBUG_EFM
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32GG\Include;..\..\..\..\..\emlib\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config;..;..\..\..\..\..\reptile\glib;..\..\..\..\..\emdrv\common\inc;..\..\..\..\..\emdrv\rtcdrv\inc
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32GG/Source/ARM/: startup_efm32gg.s
    ../../../../../Device/SiliconLabs/EFM32GG/Source/: system_efm32gg.c
  group BSP
    ../../../../common/bsp/: bsp_dk_3201.c bsp_dk_leds.c bsp_trace.c
  group Drivers
    ../../../../common/drivers/: tftamapped.c
  group glib
    ../../../../../reptile/glib/dmd/ssd2119/: dmd_ssd2119_16bit.c dmdif_ssd2119_ebi16.c
    ../../../../../reptile/glib/glib/: glib.c glib_bitmap.c glib_circle.c glib_line.c glib_polygon.c glib_rectangle.c glib_string.c glib_font_normal_8x8.c glib_font_narrow_6x8.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_system.c em_cmu.c em_emu.c em_ebi.c em_gpio.c em_usart.c em_rtc.c em_int.c
  group emdrv
    ../../../../../emdrv/rtcdrv/src/: rtcdriver.c
  group Source
    ../: emode.c
