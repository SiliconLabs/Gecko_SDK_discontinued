# IAR project usbdtouch.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32GG990F1024 SiliconLaboratories EFM32GG990F1024
  ICCARM.CCDefines: EFM32GG990F1024; DEBUG_EFM; __HEAP_SIZE=0x800; __STACK_SIZE=0x1000
  ICCARM.CCIncludePath2: ..; ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\SiliconLabs\EFM32GG\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\..\usb\inc; ..\..\..\..\common\drivers; ..\..\..\..\common\bsp; ..\..\..\config; ..\..\..\..\..\reptile\glib; ..\..\..\..\..\reptile\fatfs\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: usbdtouch.bin
  ILINK.IlinkOutputFile: usbdtouch.out
  ILINK.IlinkIcfFile: ..\usbdtouch.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32GG990F1024; DEBUG_EFM; __HEAP_SIZE=0x800; __STACK_SIZE=0x1000
  group bsp
    ../../../../common/bsp/: bsp_dk_3201.c bsp_dk_leds.c bsp_trace.c
  group Drivers
    ../../../../common/drivers/: calibrate.c eeprom.c i2cspm.c msdd.c norflash.c retargetio.c retargetserial.c tftspi.c touch.c tftdirect.c
  group graphics
    ../../../../../reptile/glib/dmd/ssd2119/: dmd_ssd2119_direct.c
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32GG/Source/IAR/: startup_efm32gg.s
    ../../../../../Device/SiliconLabs/EFM32GG/Source/: system_efm32gg.c
  group emlib
    ../../../../../emlib/src/: em_adc.c em_assert.c em_cmu.c em_ebi.c em_emu.c em_gpio.c em_int.c em_i2c.c em_system.c em_timer.c em_usart.c
  group emusb
    ../../../../../usb/src/: em_usbd.c em_usbdch9.c em_usbhal.c em_usbdep.c em_usbdint.c em_usbtimer.c
  group fatfs
    ../../../../../reptile/fatfs/src/: ff.c
  group Source
    ../: main.c fnt16x28.c bitmap.c msddmedia.c descriptors.c
