# IAR project webserver.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32GG990F1024 SiliconLaboratories EFM32GG990F1024
  ICCARM.CCDefines: EFM32GG990F1024; DEBUG_EFM; __HEAP_SIZE=128
  ICCARM.CCDiagSuppress: Pa050,Pe550
  ICCARM.CCIncludePath2: ..; ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\SiliconLabs\EFM32GG\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\..\emdrv\spidrv\inc; ..\..\..\..\..\emdrv\common\inc; ..\..\..\..\..\emdrv\config; ..\..\..\..\..\emdrv\rtcdrv\inc; ..\..\..\..\..\emdrv\dmadrv\inc; ..\..\..\..\common\drivers; ..\..\..\..\common\bsp; ..\..\..\config; ..\..\..\..\..\reptile\glib; ..\..\..\..\..\reptile\glib\glib; ..\..\..\..\..\reptile\lwIP\lwip-1.4.1\src\; ..\..\..\..\..\reptile\lwIP\lwip-1.4.1\src\api; ..\..\..\..\..\reptile\lwIP\lwip-1.4.1\src\core; ..\..\..\..\..\reptile\lwIP\lwip-1.4.1\src\core\ipv4; ..\..\..\..\..\reptile\lwIP\lwip-1.4.1\src\include; ..\..\..\..\..\reptile\lwIP\lwip-1.4.1\src\include\ipv4; ..\..\..\..\..\reptile\lwIP\lwip-1.4.1\src\include\ipv4\lwip; ..\..\..\..\..\reptile\lwIP\lwip-1.4.1\src\include\lwip; ..\..\..\..\..\reptile\lwIP\contrib-1.4.1\apps\ping; ..\..\..\..\..\reptile\lwIP\contrib-1.4.1\apps\tcpecho_raw; ..\..\..\..\..\reptile\lwIP\contrib-1.4.1\apps\httpserver_raw; ..\..\..\..\..\reptile\lwIP\contrib-1.4.1\ports\EFM32\; ..\..\..\..\..\reptile\lwIP\contrib-1.4.1\ports\EFM32\include\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: webserver.bin
  ILINK.IlinkOutputFile: webserver.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32GG990F1024; DEBUG_EFM; __HEAP_SIZE=128
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32GG/Source/IAR/: startup_efm32gg.s
    ../../../../../Device/SiliconLabs/EFM32GG/Source/: system_efm32gg.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_system.c em_cmu.c em_emu.c em_gpio.c em_ebi.c em_usart.c em_rtc.c em_dma.c em_int.c
  group emdrv
    ../../../../../emdrv/spidrv/src/: spidrv.c
    ../../../../../emdrv/rtcdrv/src/: rtcdriver.c
    ../../../../../emdrv/dmadrv/src/: dmadrv.c
  group BSP
    ../../../../common/bsp/: bsp_dk_3201.c bsp_trace.c bsp_dk_leds.c
  group Drivers
    ../../../../common/drivers/: ksz8851snl.c ksz8851snl_spi.c retargetserial.c retargetio.c dmactrl.c
    ../: tftconsole.c
    ../../../../../reptile/lwIP/contrib-1.4.1/ports/efm32/: ksz8851snl_driver.c
  group Graphics
    ../../../../../reptile/glib/dmd/ssd2119/: dmd_ssd2119_16bit.c dmdif_ssd2119_ebi16.c
  group lwIP
    ../../../../../reptile/lwIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../reptile/lwIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../../reptile/lwIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../../../reptile/lwIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group lwIP_apps
    ../../../../../reptile/lwIP/contrib-1.4.1/apps/tcpecho_raw/: echo.c
    ../../../../../reptile/lwIP/contrib-1.4.1/apps/httpserver_raw/: fs.c httpd.c
  group Source
    ../: webserver.c
