<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\rs232aG890.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\rs232aG290.ewp</path>
  </project>

  <batchBuild/>
</workspace>
