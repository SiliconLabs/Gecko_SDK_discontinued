# Keil uVision project rs232aG290.uvprojx, settings and files
target rs232aG290 (ARM-ADS)
  device: EFM32G290F128 Silicon Labs
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(14000000) CPUTYPE("Cortex-M3")
  output: rs232aG290
  AfterMake: fromelf.exe --bin --output obj\rs232aG290.bin obj\rs232aG290.axf
  c flags: Optim=1
  c define: EFM32G290F128 DEBUG_EFM
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32G\Include;..\..\..\..\..\emlib\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Drivers
    ../../../../common/drivers/: retargetio.c retargetserial.c
  group bsp
    ../../../../common/bsp/: bsp_dk_3200.c bsp_trace.c
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32G/Source/ARM/: startup_efm32g.s
    ../../../../../Device/SiliconLabs/EFM32G/Source/: system_efm32g.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_system.c em_cmu.c em_emu.c em_gpio.c em_ebi.c em_int.c em_rtc.c em_usart.c
  group Source
    ../: rs232a.c
