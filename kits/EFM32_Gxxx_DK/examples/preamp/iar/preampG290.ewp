# IAR project preampG290.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32G290F128 SiliconLaboratories EFM32G290F128
  ICCARM.CCDefines: EFM32G290F128; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\SiliconLabs\EFM32G\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\common\drivers; ..\..\..\..\common\bsp; ..\..\..\config; ..\..\..\..\..\emdrv\common\inc; ..\..\..\..\..\emdrv\rtcdrv\inc; ..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: preampG290.bin
  ILINK.IlinkOutputFile: preampG290.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32G290F128; DEBUG_EFM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32G/Source/IAR/: startup_efm32g.s
    ../../../../../Device/SiliconLabs/EFM32G/Source/: system_efm32g.c
  group Drivers
    ../../../../common/drivers/: dmactrl.c
  group bsp
    ../../../../common/bsp/: bsp_dk_3200.c bsp_dk_leds.c bsp_trace.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_adc.c em_cmu.c em_dac.c em_dma.c em_emu.c em_ebi.c em_gpio.c em_prs.c em_rtc.c em_system.c em_timer.c em_usart.c em_int.c
  group emdrv
    ../../../../../emdrv/rtcdrv/src/: rtcdriver.c
  group Source
    ../: preamp.c
