# IAR project tftemodeG290.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32G290F128 SiliconLaboratories EFM32G290F128
  ICCARM.CCDefines: EFM32G290F128; DEBUG_EFM; RTCDRV_USE_LFRCO
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\SiliconLabs\EFM32G\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\..\emdrv\common\inc; ..\..\..\..\..\emdrv\config; ..\..\..\..\..\emdrv\rtcdrv\inc; ..\..\..\..\common\bsp; ..\..\..\config; ..; ..\..\..\..\..\reptile\glib
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tftemodeG290.bin
  ILINK.IlinkOutputFile: tftemodeG290.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32G290F128; DEBUG_EFM; RTCDRV_USE_LFRCO
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32G/Source/IAR/: startup_efm32g.s
    ../../../../../Device/SiliconLabs/EFM32G/Source/: system_efm32g.c
  group glib
    ../../../../../reptile/glib/glib/: bmp.c glib.c glib_bitmap.c glib_circle.c glib_line.c glib_polygon.c glib_rectangle.c glib_string.c glib_font_normal_8x8.c
    ../../../../../reptile/glib/dmd/ssd2119/: dmd_ssd2119.c dmdif_ssd2119_ebi.c
  group bsp
    ../../../../common/bsp/: bsp_dk_3200.c bsp_dk_leds.c bsp_trace.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_dbg.c em_ebi.c em_emu.c em_gpio.c em_int.c em_rtc.c em_rmu.c em_system.c em_usart.c em_wdog.c
  group Source
    ../: tftemode.c tftamapped.c
  group Drivers
    ../../../../../emdrv/rtcdrv/src/: rtcdriver.c
