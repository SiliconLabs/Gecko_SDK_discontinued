<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\rs232bG890.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\rs232bG290.ewp</path>
  </project>

  <batchBuild/>
</workspace>
