<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\potentiometerG890.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\potentiometerG290.ewp</path>
  </project>

  <batchBuild/>
</workspace>
