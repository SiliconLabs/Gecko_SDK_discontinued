<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\tftG290.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\tftG890.ewp</path>
  </project>

  <batchBuild/>
</workspace>
