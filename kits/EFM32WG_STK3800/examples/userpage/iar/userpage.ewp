# IAR project userpage.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32WG990F256 SiliconLaboratories EFM32WG990F256
  ICCARM.CCDefines: EFM32WG990F256
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\SiliconLabs\EFM32WG\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\common\drivers; ..\..\..\config; ..\..\..\..\common\bsp; ..\..\..\..\..\emdrv\common\inc; ..\..\..\..\..\emdrv\rtcdrv\inc; ..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: userpage.bin
  ILINK.IlinkOutputFile: userpage.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32WG990F256
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32WG/Source/IAR/: startup_efm32wg.s
    ../../../../../Device/SiliconLabs/EFM32WG/Source/: system_efm32wg.c
  group Drivers
    ../../../../common/drivers/: segmentlcd.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_rtc.c em_system.c em_int.c em_msc.c em_lcd.c
  group emdrv
    ../../../../../emdrv/rtcdrv/src/: rtcdriver.c
  group BSP
    ../../../../common/bsp/: bsp_trace.c
  group Source
    ../: userpage.c
