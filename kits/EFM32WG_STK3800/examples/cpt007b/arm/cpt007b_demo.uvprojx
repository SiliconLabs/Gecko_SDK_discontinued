# Keil uVision project cpt007b_demo.uvprojx, settings and files
target cpt007b_demo (ARM-ADS)
  device: EFM32WG990F256 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(48000000) CPUTYPE("Cortex-M4") FPU2
  output: cpt007b_demo
  AfterMake: fromelf.exe --bin --output obj\cpt007b_demo.bin obj\cpt007b_demo.axf
  c flags: Optim=4 oTime=1
  c define: EFM32WG990F256 DEBUG_EFM
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32WG\Include;..\..\..\..\..\emlib\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config;..\..\..\..\..\reptile\glib;..\..\..\..\..\reptile\glib\dmd;..\..\..\..\..\reptile\glib\dmd\ssd2119;..\..\..\..\..\reptile\glib\glib
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32WG/Source/ARM/: startup_efm32wg.s
    ../../../../../Device/SiliconLabs/EFM32WG/Source/: system_efm32wg.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_lcd.c em_system.c
  group Drivers
    ../../../../common/drivers/: retargetio.c segmentlcd.c retargetswo.c
  group Source
    ../: cpt007b_demo.c
