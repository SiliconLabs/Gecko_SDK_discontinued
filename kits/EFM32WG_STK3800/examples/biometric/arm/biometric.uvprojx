# Keil uVision project biometric.uvprojx, settings and files
target biometric (ARM-ADS)
  device: EFM32WG990F256 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(48000000) CPUTYPE("Cortex-M4") FPU2
  output: biometric
  AfterMake: fromelf.exe --bin --output obj\biometric.bin obj\biometric.axf
  c flags: Optim=4 oTime=1
  c define: EFM32WG990F256 USB_DEBUG
  c misc: --c99
  c include: ..\;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Device\SiliconLabs\EFM32WG\Include;..\..\..\..\..\emlib\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\..\EFM32WG_STK3800\config;..\usb;..\..\..\..\..\emdrv\rtcdrv\inc;..\..\..\..\..\emdrv\common\inc;..\..\..\..\..\emdrv\config;..\..\..\..\..\reptile\si114xhrm\inc;..\..\..\..\..\usb\inc
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group BSP
    ../../../../common/bsp/: bsp_bcc.c bsp_stk.c bsp_trace.c
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32WG/Source/ARM/: startup_efm32wg.s
    ../../../../../Device/SiliconLabs/EFM32WG/Source/: system_efm32wg.c
  group Drivers
    ../../../../common/drivers/: segmentlcd.c i2cspm.c si7013.c si114x_functions.c si114x_sys_out.c si114x_uv_index.c
    ../../../../../emdrv/rtcdrv/src/: rtcdriver.c
  group Graphics
    ../: graphics.c
  group USB
    ../../../../../usb/src/: em_usbd.c em_usbdch9.c em_usbdep.c em_usbhal.c em_usbtimer.c em_usbdint.c
    ../usb/: descriptors.c usb_debug.c
  group emlib
    ../../../../../emlib/src/: em_adc.c em_assert.c em_cmu.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_lcd.c em_prs.c em_system.c em_timer.c em_usart.c em_int.c em_rtc.c em_i2c.c
  group Source
    ../: biometric_demo.c heart_rate_monitor.c
  group Libraries
    ../../../../../reptile/si114xhrm/lib/: si114xHRM_ARM_CM4F.lib
