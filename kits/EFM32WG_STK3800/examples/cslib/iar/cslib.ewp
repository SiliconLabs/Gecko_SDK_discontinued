# IAR project cslib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32WG990F256 SiliconLaboratories EFM32WG990F256
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32WG990F256; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\SiliconLabs\EFM32WG\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\common\bsp; ..\..\..\config; ..\..\..\..\..\reptile\cslib\inc; ..\..\..\..\..\reptile\cslib\src\app; ..\..\..\..\..\reptile\cslib\src\device_LESENSE; ..\..\..\..\..\reptile\cslib\src\serial; ..\..\..\..\..\reptile\cslib\src\config_LESENSE; ..\..\..\..\..\emdrv\rtcdrv\inc; ..\..\..\..\..\emdrv\common\inc; ..\..\..\..\common\drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cslib.bin
  ILINK.IlinkOutputFile: cslib.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\reptile\cslib\lib\libCSLIB_M3_4_iar.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32WG990F256; DEBUG_EFM
  group CMSIS
    ../../../../../Device/SiliconLabs/EFM32WG/Source/IAR/: startup_efm32wg.s
    ../../../../../Device/SiliconLabs/EFM32WG/Source/: system_efm32wg.c
  group bsp
    ../../../../common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
  group drivers
    ../../../../../emdrv/rtcdrv/src/: rtcdriver.c
  group emlib
    ../../../../../emlib/src/: em_acmp.c em_assert.c em_cmu.c em_ebi.c em_emu.c em_gpio.c em_int.c em_lesense.c em_rtc.c em_system.c em_vcmp.c em_leuart.c em_usart.c
  group app
    ../../../../../reptile/cslib/src/app/: cslib_config.c device_init.c main.c
  group device_LESENSE
    ../../../../../reptile/cslib/src/device_LESENSE/: hardware_config.c hardware_routines.c low_power_config.c
  group serial
    ../../../../../reptile/cslib/src/serial/: comm_routines.c profiler_interface.c retargetvirtual.c sensor_descriptors.c
    ../../../../common/drivers/: retargetio.c
