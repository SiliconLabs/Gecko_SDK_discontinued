# Keil uVision project webserver.uvprojx, settings and files
target webserver (ARM-ADS)
  device: EFM32WG990F256 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(48000000) CPUTYPE("Cortex-M4") FPU2
  output: webserver
  AfterMake: fromelf.exe --bin --output obj\webserver.bin obj\webserver.axf
  c flags: Optim=4 oTime=1
  c define: EFM32WG990F256 DEBUG_EFM __HEAP_SIZE=128
  c misc: --c99 --diag_suppress=C550,C1295
  c include: ..\;..;..\..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\..\platform\Device\SiliconLabs\EFM32WG\Include;..\..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\..\platform\emdrv\common\inc;..\..\..\..\..\..\platform\emdrv\spidrv\inc;..\..\..\..\..\..\platform\emdrv\spidrv\config;..\..\..\..\..\..\platform\emdrv\rtcdrv\inc;..\..\..\..\..\..\platform\emdrv\rtcdrv\config;..\..\..\..\..\..\platform\emdrv\dmadrv\inc;..\..\..\..\..\..\platform\emdrv\dmadrv\config;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config;..\..\..\..\..\..\platform\middleware\glib;..\..\..\..\..\..\platform\middleware\glib\glib;..\..\..\..\..\..\util\third_party\lwip\lwip\src\;..\..\..\..\..\..\util\third_party\lwip\lwip\src\api;..\..\..\..\..\..\util\third_party\lwip\lwip\src\core;..\..\..\..\..\..\util\third_party\lwip\lwip\src\core\ipv4;..\..\..\..\..\..\util\third_party\lwip\lwip\src\include;..\..\..\..\..\..\util\third_party\lwip\lwip\src\include\ipv4;..\..\..\..\..\..\util\third_party\lwip\lwip\src\include\ipv4\lwip;..\..\..\..\..\..\util\third_party\lwip\lwip\src\include\lwip;..\..\..\..\..\..\util\third_party\lwip\lwip-contrib\apps\ping;..\..\..\..\..\..\util\third_party\lwip\lwip-contrib\apps\tcpecho_raw;..\..\..\..\..\..\util\third_party\lwip\lwip-contrib\apps\httpserver_raw;..\..\..\..\..\..\util\third_party\lwip\lwip-contrib\ports\EFM32\;..\..\..\..\..\..\util\third_party\lwip\lwip-contrib\ports\EFM32\include\
  asm define: EFM32WG990F256 DEBUG_EFM __HEAP_SIZE=128
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../../../../platform/Device/SiliconLabs/EFM32WG/Source/ARM/: startup_efm32wg.s
    ../../../../../../platform/Device/SiliconLabs/EFM32WG/Source/: system_efm32wg.c
  group emlib
    ../../../../../../platform/emlib/src/: em_assert.c em_system.c em_cmu.c em_core.c em_emu.c em_gpio.c em_ebi.c em_usart.c em_rtc.c em_dma.c
  group emdrv
    ../../../../../../platform/emdrv/spidrv/src/: spidrv.c
    ../../../../../../platform/emdrv/rtcdrv/src/: rtcdriver.c
    ../../../../../../platform/emdrv/dmadrv/src/: dmadrv.c
  group BSP
    ../../../../common/bsp/: bsp_dk_3201.c bsp_trace.c bsp_dk_leds.c
  group Drivers
    ../../../../common/drivers/: ksz8851snl.c ksz8851snl_spi.c retargetserial.c retargetio.c dmactrl.c
    ../: tftconsole.c
  group Graphics
    ../../../../../../platform/middleware/glib/dmd/ssd2119/: dmd_ssd2119_16bit.c dmdif_ssd2119_ebi16.c
  group lwip
    ../../../../../../util/third_party/lwip/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../../util/third_party/lwip/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../../../util/third_party/lwip/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../../../../util/third_party/lwip/lwip/src/netif/: etharp.c ethernetif.c
  group lwip-contrib
    ../../../../../../util/third_party/lwip/lwip-contrib/apps/tcpecho_raw/: echo.c
    ../../../../../../util/third_party/lwip/lwip-contrib/apps/httpserver_raw/: fs.c httpd.c
    ../../../../../../util/third_party/lwip/lwip-contrib/ports/efm32/: ksz8851snl_driver.c
  group Source
    ../: webserver.c
