# IAR project clock.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32WG990F256 SiliconLaboratories EFM32WG990F256
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32WG990F256
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\..\platform\Device\SiliconLabs\EFM32WG\Include; ..\..\..\..\..\..\platform\emlib\inc; ..\..\..\..\common\drivers; ..\..\..\..\common\bsp; ..\..\..\config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: clock.bin
  ILINK.IlinkOutputFile: clock.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32WG990F256
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group CMSIS
    ../../../../../../platform/Device/SiliconLabs/EFM32WG/Source/IAR/: startup_efm32wg.s
    ../../../../../../platform/Device/SiliconLabs/EFM32WG/Source/: system_efm32wg.c
  group bsp
    ../../../../common/bsp/: bsp_trace.c
  group Drivers
    ../../../../common/drivers/: vddcheck.c segmentlcd.c
  group emlib
    ../../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_rtc.c em_system.c em_lcd.c em_vcmp.c
  group Source
    ../: clock.c
