# IAR project graphxy_mm.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32G890F128 SiliconLaboratories EFM32G890F128
  ICCARM.CCDefines: EFM32G890F128; DEBUG_EFM; ENERGY_AWARE
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\..\platform\Device\SiliconLabs\EFM32G\Include; ..\..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\..\util\third_party\emwin\inc; ..\..\..\..\..\..\platform\middleware\glib; ..\..\..\..\common\drivers\emwin\Dk3550; ..\..\..\..\common\drivers; ..\..\..\..\common\bsp; ..\..\..\config
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: graphxy_mm.bin
  ILINK.IlinkOutputFile: graphxy_mm.out
  ILINK.IlinkIcfFile: ..\graphxy.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\util\third_party\emwin\lib\emwin_IAR_CM3.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32G890F128; DEBUG_EFM; ENERGY_AWARE
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../../platform/Device/SiliconLabs/EFM32G/Source/IAR/: startup_efm32g.s
    ../../../../../../platform/Device/SiliconLabs/EFM32G/Source/: system_efm32g.c
  group emlib
    ../../../../../../platform/emlib/src/: em_assert.c em_adc.c em_cmu.c em_emu.c em_system.c em_rtc.c em_wdog.c em_gpio.c em_ebi.c em_usart.c em_i2c.c
  group bsp
    ../../../../common/bsp/: bsp_dk_3201.c bsp_trace.c
  group Drivers
    ../../../../common/drivers/: calibrate.c touch.c eeprom.c i2cspm.c
  group emwin
    ../../../../common/drivers/emwin/Dk3550/: GUI_X.c GUIConf.c LCDConf.c ssd2119.c
  group Source
    ../: WIDGET_GraphXY.c
