# IAR project cpt112s_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32G890F128 SiliconLaboratories EFM32G890F128
  ICCARM.CCDefines: EFM32G890F128; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\..\platform\Device\SiliconLabs\EFM32G\Include; ..\..\..\..\..\..\platform\emlib\inc; ..\..\..\..\common\drivers; ..\..\..\..\common\bsp; ..\..\..\config; ..\..\..\..\..\..\platform\middleware\glib; ..\..\..\..\..\..\platform\middleware\glib\dmd; ..\..\..\..\..\..\platform\middleware\glib\dmd\ssd2119; ..\..\..\..\..\..\platform\middleware\glib\glib
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cpt112s_demo.bin
  ILINK.IlinkOutputFile: cpt112s_demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32G890F128; DEBUG_EFM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group BSP
    ../../../../common/bsp/: bsp_trace.c
  group CMSIS
    ../../../../../../platform/Device/SiliconLabs/EFM32G/Source/IAR/: startup_efm32g.s
    ../../../../../../platform/Device/SiliconLabs/EFM32G/Source/: system_efm32g.c
  group emlib
    ../../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_i2c.c em_lcd.c em_system.c
  group Drivers
    ../../../../common/drivers/: cpt112s_i2c.c retargetio.c retargetswo.c segmentlcd.c
  group Source
    ../: cpt112s_demo.c
