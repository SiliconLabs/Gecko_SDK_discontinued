<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\JoystickG890.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\JoystickG290.ewp</path>
  </project>

  <batchBuild/>
</workspace>
