<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\periphG890.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periphG290.ewp</path>
  </project>

  <batchBuild/>
</workspace>
