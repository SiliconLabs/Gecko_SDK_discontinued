# IAR project rs232aG290.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32G290F128 SiliconLaboratories EFM32G290F128
  ICCARM.CCDefines: EFM32G290F128; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\..\platform\Device\SiliconLabs\EFM32G\Include; ..\..\..\..\..\..\platform\emlib\inc; ..\..\..\..\common\drivers; ..\..\..\..\common\bsp; ..\..\..\config
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: rs232aG290.bin
  ILINK.IlinkOutputFile: rs232aG290.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32G290F128; DEBUG_EFM
  group Drivers
    ../../../../common/drivers/: retargetio.c retargetserial.c
  group bsp
    ../../../../common/bsp/: bsp_dk_3200.c bsp_trace.c
  group CMSIS
    ../../../../../../platform/Device/SiliconLabs/EFM32G/Source/IAR/: startup_efm32g.s
    ../../../../../../platform/Device/SiliconLabs/EFM32G/Source/: system_efm32g.c
  group emlib
    ../../../../../../platform/emlib/src/: em_assert.c em_system.c em_cmu.c em_core.c em_emu.c em_gpio.c em_ebi.c em_rtc.c em_usart.c
  group Source
    ../: rs232a.c
