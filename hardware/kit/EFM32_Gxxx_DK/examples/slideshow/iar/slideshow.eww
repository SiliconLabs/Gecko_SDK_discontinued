<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\slideshowG290.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\slideshowG890.ewp</path>
  </project>

  <batchBuild/>
</workspace>
