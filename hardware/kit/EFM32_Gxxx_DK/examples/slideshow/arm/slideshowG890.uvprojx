# Keil uVision project slideshowG890.uvprojx, settings and files
target slideshowG890 (ARM-ADS)
  device: EFM32G890F128 Silicon Labs
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(14000000) CPUTYPE("Cortex-M3")
  output: slideshowG890
  AfterMake: fromelf.exe --bin --output obj\slideshowG890.bin obj\slideshowG890.axf
  c flags: Optim=4 oTime=1
  c define: EFM32G890F128 DEBUG_EFM
  c misc: --c99
  c include: ..\;..\..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\..\platform\Device\SiliconLabs\EFM32G\Include;..\..\..\..\..\..\platform\emlib\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config;..\..\..\..\..\..\util\third_party\fatfs\inc\;..;..\..\..\..\..\..\platform\middleware\glib
  asm define: EFM32G890F128 DEBUG_EFM
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../../../../../../platform/Device/SiliconLabs/EFM32G/Source/ARM/: startup_efm32g.s
    ../../../../../../platform/Device/SiliconLabs/EFM32G/Source/: system_efm32g.c
  group glib
    ../../../../../../platform/middleware/glib/glib/: bmp.c glib.c glib_bitmap.c glib_circle.c glib_line.c glib_polygon.c glib_rectangle.c glib_string.c glib_font_normal_8x8.c
    ../../../../../../platform/middleware/glib/dmd/ssd2119/: dmd_ssd2119.c dmdif_ssd2119_spi.c
  group emlib
    ../../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_dbg.c em_emu.c em_ebi.c em_gpio.c em_rtc.c em_rmu.c em_system.c em_usart.c em_wdog.c
  group Drivers
    ../../../../common/drivers/: microsd.c
  group bsp
    ../../../../common/bsp/: bsp_dk_3200.c bsp_trace.c
  group FatFS
    ../../../../../../util/third_party/fatfs/src/: diskio.c ff.c
  group Source
    ../: slideshow.c slides.c
