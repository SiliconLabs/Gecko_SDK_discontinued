# IAR project iec60335G290.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32G290F128 SiliconLaboratories EFM32G290F128
  ICCARM.CCDefines: EFM32G290F128
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\..\platform\Device\SiliconLabs\EFM32G\Include; ..\..\..\..\..\..\platform\emlib\inc; ..\..\..\..\common\drivers; ..\..\..\..\common\bsp; ..\..\..\config; ..\..\..\..\..\..\util\third_party\iec60335_classb\lib\inc; ..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: iec60335G290.bin
  ILINK.IlinkOutputFile: iec60335G290.out
  ILINK.IlinkIcfFile: ..\EFM32Gx90F128.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32G290F128
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../: startup_efm32g_iar.s
    ../../../../../../platform/Device/SiliconLabs/EFM32G/Source/: system_efm32g.c
  group emlib
    ../../../../../../platform/emlib/src/: em_cmu.c em_emu.c
  group Iec60335
    ../../../../../../util/third_party/iec60335_classb/lib/src/: iec60335_class_b_timer_rtc_test.c iec60335_class_b_interrupt_test.c iec60335_class_b_flash_test.c iec60335_class_b_cpureg_test.c iec60335_class_b_programcounter_test.c iec60335_class_b_ram_test.c iec60335_class_b_post.c iec60335_class_b_cpureg_test_bist_iar.s iec60335_class_b_cpureg_test_post_iar.s
  group Source
    ../: main.c
