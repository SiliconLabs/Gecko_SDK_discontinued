# Keil uVision project iec60335G290.uvprojx, settings and files
target iec60335G290 (ARM-ADS)
  device: EFM32G290F128 Silicon Labs
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(14000000) CPUTYPE("Cortex-M3")
  output: iec60335G290
  AfterMake: fromelf.exe --bin --output obj\iec60335G290.bin obj\iec60335G290.axf
  c flags: Optim=1 oTime=1
  c define: EFM32G290F128
  c misc: --c99
  c include: ..\;..\..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\..\platform\Device\SiliconLabs\EFM32G\Include;..\..\..\..\..\..\platform\emlib\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config;..\..\..\..\..\..\util\third_party\iec60335_classb\lib\inc;..
  asm define: EFM32G290F128
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../: startup_efm32g_arm.s
    ../../../../../../platform/Device/SiliconLabs/EFM32G/Source/: system_efm32g.c
  group emlib
    ../../../../../../platform/emlib/src/: em_cmu.c em_emu.c
  group Iec60335
    ../../../../../../util/third_party/iec60335_classb/lib/src/: iec60335_class_b_timer_rtc_test.c iec60335_class_b_interrupt_test.c iec60335_class_b_flash_test.c iec60335_class_b_cpureg_test.c iec60335_class_b_programcounter_test.c iec60335_class_b_ram_test.c iec60335_class_b_post.c iec60335_class_b_cpureg_test_bist_arm.s iec60335_class_b_cpureg_test_post_arm.s
  group Source
    ../: main.c
