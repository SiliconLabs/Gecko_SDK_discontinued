# Keil uVision project rs232bG890.uvprojx, settings and files
target rs232bG890 (ARM-ADS)
  device: EFM32G890F128 Silicon Labs
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(14000000) CPUTYPE("Cortex-M3")
  output: rs232bG890
  AfterMake: fromelf.exe --bin --output obj\rs232bG890.bin obj\rs232bG890.axf
  c flags: Optim=4 oTime=1
  c define: EFM32G890F128 DEBUG_EFM RETARGET_LEUART1
  c misc: --c99
  c include: ..\;..\..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\..\platform\Device\SiliconLabs\EFM32G\Include;..\..\..\..\..\..\platform\emlib\inc;..\..\..\..\common\drivers;..\..\..\..\common\bsp;..\..\..\config
  asm define: EFM32G890F128 DEBUG_EFM RETARGET_LEUART1
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Drivers
    ../../../../common/drivers/: retargetio.c retargetserial.c
  group bsp
    ../../../../common/bsp/: bsp_dk_3200.c bsp_trace.c
  group CMSIS
    ../../../../../../platform/Device/SiliconLabs/EFM32G/Source/ARM/: startup_efm32g.s
    ../../../../../../platform/Device/SiliconLabs/EFM32G/Source/: system_efm32g.c
  group emlib
    ../../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_emu.c em_ebi.c em_gpio.c em_leuart.c em_usart.c em_rtc.c em_system.c
  group Source
    ../: rs232b.c
