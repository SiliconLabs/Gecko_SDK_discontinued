# IAR project temperatureG890.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32G890F128 SiliconLaboratories EFM32G890F128
  ICCARM.CCDefines: EFM32G890F128; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\..\platform\Device\SiliconLabs\EFM32G\Include; ..\..\..\..\..\..\platform\emlib\inc; ..\..\..\..\common\drivers; ..\..\..\..\common\bsp; ..\..\..\config; ..\..\..\..\..\..\platform\emdrv\common\inc; ..\..\..\..\..\..\platform\emdrv\rtcdrv\inc; ..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: temperatureG890.bin
  ILINK.IlinkOutputFile: temperatureG890.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32G890F128; DEBUG_EFM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group CMSIS
    ../../../../../../platform/Device/SiliconLabs/EFM32G/Source/IAR/: startup_efm32g.s
    ../../../../../../platform/Device/SiliconLabs/EFM32G/Source/: system_efm32g.c
  group Drivers
    ../../../../common/drivers/: i2cspm.c tempsens.c segmentlcd.c
  group bsp
    ../../../../common/bsp/: bsp_dk_3200.c bsp_dk_leds.c bsp_trace.c
  group emlib
    ../../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_ebi.c em_emu.c em_gpio.c em_i2c.c em_rtc.c em_system.c em_usart.c em_lcd.c
  group emdrv
    ../../../../../../platform/emdrv/rtcdrv/src/: rtcdriver.c
  group Source
    ../: temperature.c
